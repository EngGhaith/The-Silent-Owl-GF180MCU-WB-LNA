v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 120 -20 220 -20 {lab=G}
N 120 -1120 220 -1120 {lab=G}
N 120 -570 190 -570 {lab=G}
N 210 -1120 220 -1120 {lab=G}
N 220 -1120 220 -20 {lab=G}
N 190 -570 220 -570 {lab=G}
C {iopin.sym} 120 -1120 0 1 {name=p1 lab=G}
C {iopin.sym} 120 -570 0 1 {name=p2 lab=DEEMB}
C {iopin.sym} 120 -20 0 1 {name=p3 lab=G}
