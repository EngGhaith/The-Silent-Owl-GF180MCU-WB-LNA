v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 440 -300 470 -300 {lab=rf_out_pad}
N 230 -300 320 -300 {lab=output_cs}
N 380 -300 440 -300 {lab=rf_out_pad}
C {iopin.sym} 470 -300 0 0 {name=p58 lab=rf_out_pad}
C {symbols/cap_mim_2f0fF.sym} 350 -300 3 0 {name=C11
W=28u
L=28u
model=cap_mim_2f0_m4m5_noshield
spiceprefix=X
m=1}
C {ipin.sym} 230 -300 0 0 {name=p3 lab=output_cs}
