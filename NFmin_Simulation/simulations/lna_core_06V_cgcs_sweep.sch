** sch_path: NFmin_Simulation/simulations/lna_core_06V_cgcs_sweep.sch
**.subckt lna_core_06V_cgcs_sweep
VBCG vbias_cg GND {VBIAS_CG}
VDD vdcbias GND {VDS}
C12 d g_cs {C12_VAL} m=1
CIN net7 s {CIN_VAL} m=1
V1 rf_in_ext GND DC 0 AC 1 0 portnum 1 z0 50
V2 rf_out_ext GND DC 0 AC 1 0 portnum 2 z0 50
XM2 d g_cg s GND nfet_06v0 L={L_CG} W={W_CG} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CG}
RBCG g_cg vbias_cg {RBIAS_CG} m=1
CBCG g_cg GND {CBYP_CG} m=1
x1 rf_in_pad vddio GND vddio GND gf180mcu_fd_io__asig_5p0
LBW_IN rf_in_pad net1 {L_BW} m=1
RBW_IN net1 rf_in_ext {R_BW} m=1
VDDIO vddio GND {VDDIO_SUP}
x2 rf_out_pad vddio GND vddio GND gf180mcu_fd_io__asig_5p0
LBW_IN1 rf_out_pad net2 {L_BW} m=1
RBW_IN1 net2 rf_out_ext {R_BW} m=1
VBCS vbias_cs GND {VBIAS_CS}
RD1_LOAD vdcbias d {RD1} m=1
XM1 net8 g_cs GND GND nfet_06v0 L={L_CS} W={W_CS} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CS}
RBCS g_cs vbias_cs {RBIAS_CS} m=1
RD2_LOAD vdcbias net9 {RD2} m=1
XM3 net10 g_buf net3 GND nfet_06v0 L={L_SF} W={W_SF} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_SF}
COUT vbuf net4 {COUT_VAL} m=1
LOUT net5 net4 {L_OUT} m=1
RLOUT rf_out_pad net5 {R_L_OUT} m=1
CSHOUT rf_out_pad GND {C_SH_OUT} m=1
CSHIN rf_in_pad GND {C_SH_IN} m=1
LIN net6 rf_in_pad {L_IN} m=1
RLIN net7 net6 {R_L_IN} m=1
XM4 net9 vbias_cas net8 GND nfet_06v0 L={L_CAS} W={W_CAS} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CAS}
VBCS1 vbias_cas GND {VBIAS_CAS}
VBCS2 vbias_buf GND {VBIAS_BUF}
VBCS3 vbias_icg GND {VBIAS_ICG}
XM5 s vbias_icg GND GND nfet_03v3 L={L_BIAS_CG} W={W_BIAS_CG} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u'
+ as='int((nf+2)/2) * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)'
+ nrd='0.18u / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m={M_BIAS_CG}
C23 net9 g_buf {C23_VAL} m=1
RD_OUT vdcbias vbuf {RD_OUT} m=1
RS_OUT net3 GND {RS_OUT} m=1
CSOUT net3 GND {CSOUT_VAL} m=1
RBCS1 g_buf vbias_buf {RBIAS_BUF} m=1
XM6 vbuf vbias_cas_buf net10 GND nfet_06v0 L={L_SF_CAS} W={W_SF_CAS} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u'
+ as='int((nf+2)/2) * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)'
+ nrd='0.18u / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m={M_SF_CAS}
VBCS4 vbias_cas_buf GND {VBIAS_CAS_BUF}
**** begin user architecture code

.include /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice

.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_typical

*.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/spice/gf180mcu_fd_io.spice
.include /media/sf_LNA_chipathon/The-Silent-Owl-GF180MCU-WB-LNA/analog_pad_sp_paramerters/xschem/gf180mcu_fd_io__asig_5p0.spice




* =============================================================================

* SUPPLY / PACKAGE

* =============================================================================
.param L_OUT=1n
.param VDS=5.0

.param VDDIO_SUP=5.0

.param L_BW=2n

.param R_BW=0.2



* =============================================================================

* INPUT NETWORK — only intentional inductor

* =============================================================================

.param L_IN=2.0n

.param R_L_IN=1.5

.param CIN_VAL=100p

.param C_SH_IN=1f



* =============================================================================

* COMMON-GATE INPUT STAGE — V20 starting point

* =============================================================================

.param VBIAS_CG=2.10

.param W_CG=130u

.param M_CG=2

.param L_CG=0.60u

.param RD1=660

.param RBIAS_CG=50k

.param CBYP_CG=20p



* =============================================================================

* CS-CASCODE INTERMEDIATE STAGE

* =============================================================================

.param C12_VAL=100p

.param VBIAS_CS=1.25

.param W_CS=70u

.param M_CS=2

.param L_CS=0.60u

.param RBIAS_CS=50k

.param VBIAS_CAS=3.30

.param W_CAS=100u

.param M_CAS=1

.param L_CAS=0.60u

.param RD2=470



* =============================================================================

* REAL XM5 COMMON-GATE CURRENT SINK

* =============================================================================

.param VBIAS_ICG=1.60

.param L_BIAS_CG=0.50u

.param W_BIAS_CG=35u

.param M_BIAS_CG=1



* =============================================================================

* BOTTOM COMMON-SOURCE OUTPUT DEVICE XM3

* =============================================================================

.param W_SF=125u

.param M_SF=2

.param L_SF=0.60u

.param VBIAS_BUF=1.75

.param RBIAS_BUF=50k

.param C23_VAL=10p



* =============================================================================

* UPPER OUTPUT CASCODE XM6 — nfet_06v0

* =============================================================================

.param W_SF_CAS=100u

.param M_SF_CAS=2

.param L_SF_CAS=0.60u

.param VBIAS_CAS_BUF=2.80



* =============================================================================

* OUTPUT LOAD / SOURCE NETWORK — no intentional output inductor

* =============================================================================

.param RD_OUT=100

.param RS_OUT=0.5

.param CSOUT_VAL=100p

.param COUT_VAL=33p

.param R_L_OUT=1.5

.param C_SH_OUT=1f



.control

set noaskquit

set wr_singlescale

set wr_vecnames

set numdgt=10

set appendwrite



* =============================================================================

* FORMAL TARGETS AND DC VALIDITY

* =============================================================================

let target_s11 = -10

let target_s22 = -10

let target_gain = 12.0

let target_nf = 4.0

let target_ripple = 1.20

let target_pdc = 220

let target_mu = 1.05

let target_delta = 1.0

let target_ltotal = 2.0e-9



let min_satmargin_sink = 0.20

let min_satmargin_core = 0.40

let min_satmargin_cg = 0.50

let min_satmargin_out_cs = 0.30

let min_satmargin_out_cas = 0.40



* =============================================================================

* OUTPUT FILES

* =============================================================================

echo ============================================================ >
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

echo LNA_V22_CORRECTED_NODE_MAPPING_REAL_XM5_CS_CASCODE_OUTPUT_DRIVER >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

echo REQUIRED_COUT_CONNECTION COUT_vbuf_to_net4 >> lna_v22_cs_cascode_driver_corrected_detailed.txt
echo CORRECT_NODE_ORDER VBUF_OUTPUT_GT_NET9_INTERNAL_GT_NET3_SOURCE >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

echo XM3_BOTTOM_CS XM6_UPPER_CASCODE BOTH_NFET_06V0 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

echo NO_INTENTIONAL_OUTPUT_INDUCTOR >> lna_v22_cs_cascode_driver_corrected_detailed.txt

echo MAX_INTENTIONAL_INPUT_INDUCTOR_2NH >> lna_v22_cs_cascode_driver_corrected_detailed.txt

echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



echo ============================================================ >
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo LNA_V22_CORRECTED_NODE_MAPPING_REAL_XM5_CS_CASCODE_OUTPUT_DRIVER_SUMMARY >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_BAND_HZ 2.30e9 2.50e9 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_S11_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_S22_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_GAIN_MIN_dB 12.0 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_NF_MAX_dB 4.0 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_GAIN_RIPPLE_MAX_dB 1.20 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_PDC_MAX_mW 220 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TARGET_MU_AND_MUP_MIN 1.05 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo MAX_INTENTIONAL_INDUCTANCE_H 2.0e-9 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo OUTPUT_INDUCTOR_H 0 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_A_CANDIDATES 1200 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_B_CANDIDATES 210 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_C_CANDIDATES 35 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_D_CANDIDATES 24 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_E_CANDIDATES 243 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo TOTAL_CANDIDATES 1712 >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* STAGE A — JOINT XM3/XM6 GEOMETRY, BIASES AND COARSE RD

* 4 W3 x 4 W6 x 5 VB3 x 5 VBCAS x 3 RD = 1200 points.

* Source is nearly RF-grounded during this topology search.

* =============================================================================

set A_best_score = 1e99

set A_best_w3 = 125u

set A_best_w6 = 100u

set A_best_vb3 = 1.75

set A_best_vb6 = 2.80

set A_best_rd = 100

set A_best_passall = 0



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_A_JOINT_OUTPUT_CASCODE_GEOMETRY_AND_BIAS >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo W3 W6 VB3 VBCAS RD SCORE DCVALID PASSCOUNT PASSALL PDC VS3 VX VOUT ID3 GM3 SAT3 ID6 GM6 SAT6
+ S11W S21MIN S21MAX RIPPLE S22W NFW MU MUP DELTA >> lna_v22_cs_cascode_driver_corrected_summary.txt



foreach w3 100u 125u 150u 175u

  foreach w6 75u 100u 125u 150u

    foreach vb3 1.55 1.65 1.75 1.85 1.95

      foreach vb6 2.4 2.6 2.8 3.0 3.2

        foreach rdv 82 120 150

          alterparam W_SF = $w3

          alterparam W_SF_CAS = $w6

          alterparam VBIAS_BUF = $vb3

          alterparam VBIAS_CAS_BUF = $vb6

          alterparam RD_OUT = $rdv

          alterparam RS_OUT = 0.5

          alterparam CSOUT_VAL = 100p

          alterparam COUT_VAL = 33p

          alterparam C_SH_OUT = 1f

          alterparam L_IN = 2.0n

          alterparam C_SH_IN = 1f



reset

        op



        * ----- DC operating point -----

        let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

        let vscgop = v(s)

        let vdcgop = v(d)

        let v7op = v(net7)

        let v8op = v(net8)

        let vg3op = v(g_buf)

        let vs3op = v(net3)

        let vxop = v(net9)

        let voutop = v(vbuf)



        let id1op = abs(@m.xm1.m0[id])

        let gm1op = @m.xm1.m0[gm]

        let gds1op = @m.xm1.m0[gds]

        let vds1op = v(net7)

        let vdsat1op = abs(@m.xm1.m0[vdsat])

        let sat1op = vds1op-vdsat1op



        let id2op = abs(@m.xm2.m0[id])

        let gm2op = @m.xm2.m0[gm]

        let gmb2op = @m.xm2.m0[gmbs]

        let gm2effop = gm2op+gmb2op

        let gds2op = @m.xm2.m0[gds]

        let vds2op = v(d)-v(s)

        let vdsat2op = abs(@m.xm2.m0[vdsat])

        let sat2op = vds2op-vdsat2op



        let id3op = abs(@m.xm3.m0[id])

        let gm3op = @m.xm3.m0[gm]

        let gmb3op = @m.xm3.m0[gmbs]

        let gds3op = @m.xm3.m0[gds]

        let gmid3op = gm3op/id3op

        let vgs3op = v(g_buf)-v(net3)

        let vds3op = v(net9)-v(net3)

        let vdsat3op = abs(@m.xm3.m0[vdsat])

        let sat3op = vds3op-vdsat3op

        let ro3op = 1/gds3op



        let id4op = abs(@m.xm4.m0[id])

        let gm4op = @m.xm4.m0[gm]

        let gds4op = @m.xm4.m0[gds]

        let vds4op = v(net8)-v(net7)

        let vdsat4op = abs(@m.xm4.m0[vdsat])

        let sat4op = vds4op-vdsat4op



        let id5op = abs(@m.xm5.m0[id])

        let gm5op = @m.xm5.m0[gm]

        let gds5op = @m.xm5.m0[gds]

        let gmid5op = gm5op/id5op

        let vds5op = v(s)

        let vdsat5op = abs(@m.xm5.m0[vdsat])

        let sat5op = vds5op-vdsat5op

        let ro5op = 1/gds5op



        let id6op = abs(@m.xm6.m0[id])

        let gm6op = @m.xm6.m0[gm]

        let gmb6op = @m.xm6.m0[gmbs]

        let gds6op = @m.xm6.m0[gds]

        let gmid6op = gm6op/id6op

        let vgs6op = v(vbias_cas_buf)-v(net9)

        let vds6op = v(vbuf)-v(net9)

        let vdsat6op = abs(@m.xm6.m0[vdsat])

        let sat6op = vds6op-vdsat6op

        let ro6op = 1/gds6op



        let ratio25op = gm2effop/gm5op



        set op_pdc = $&pdcop

        set op_vscg = $&vscgop

        set op_vdcg = $&vdcgop

        set op_v7 = $&v7op

        set op_v8 = $&v8op

        set op_vg3 = $&vg3op

        set op_vs3 = $&vs3op

        set op_vx = $&vxop

        set op_vout = $&voutop



        set op_id1 = $&id1op

        set op_gm1 = $&gm1op

        set op_gds1 = $&gds1op

        set op_vds1 = $&vds1op

        set op_vdsat1 = $&vdsat1op

        set op_sat1 = $&sat1op



        set op_id2 = $&id2op

        set op_gm2 = $&gm2op

        set op_gmb2 = $&gmb2op

        set op_gm2eff = $&gm2effop

        set op_gds2 = $&gds2op

        set op_vds2 = $&vds2op

        set op_vdsat2 = $&vdsat2op

        set op_sat2 = $&sat2op



        set op_id3 = $&id3op

        set op_gm3 = $&gm3op

        set op_gmb3 = $&gmb3op

        set op_gds3 = $&gds3op

        set op_gmid3 = $&gmid3op

        set op_vgs3 = $&vgs3op

        set op_vds3 = $&vds3op

        set op_vdsat3 = $&vdsat3op

        set op_sat3 = $&sat3op

        set op_ro3 = $&ro3op



        set op_id4 = $&id4op

        set op_gm4 = $&gm4op

        set op_gds4 = $&gds4op

        set op_vds4 = $&vds4op

        set op_vdsat4 = $&vdsat4op

        set op_sat4 = $&sat4op



        set op_id5 = $&id5op

        set op_gm5 = $&gm5op

        set op_gds5 = $&gds5op

        set op_gmid5 = $&gmid5op

        set op_vds5 = $&vds5op

        set op_vdsat5 = $&vdsat5op

        set op_sat5 = $&sat5op

        set op_ro5 = $&ro5op



        set op_id6 = $&id6op

        set op_gm6 = $&gm6op

        set op_gmb6 = $&gmb6op

        set op_gds6 = $&gds6op

        set op_gmid6 = $&gmid6op

        set op_vgs6 = $&vgs6op

        set op_vds6 = $&vds6op

        set op_vdsat6 = $&vdsat6op

        set op_sat6 = $&sat6op

        set op_ro6 = $&ro6op

        set op_ratio25 = $&ratio25op



        destroy $curplot



        * ----- RF/noise/stability over target band -----

        sp lin 51 2.30G 2.50G 1

        let s11db = db(s_1_1)

        let s21db = db(s_2_1)

        let s12db = db(s_1_2)

        let s22db = db(s_2_2)

        let nfdb = real(NF)



        let delta = s_1_1*s_2_2-s_1_2*s_2_1

        let md = mag(delta)

        let a11 = mag(s_1_1)

        let a12 = mag(s_1_2)

        let a21 = mag(s_2_1)

        let a22 = mag(s_2_2)

        let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))

        let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

        let kval = (1-a11*a11-a22*a22+md*md)/(2*a12*a21)



        let zin = 50*(1+s_1_1)/(1-s_1_1)

        let zout = 50*(1+s_2_2)/(1-s_2_2)

        let zin_re = real(zin)

        let zin_im = imag(zin)

        let zout_re = real(zout)

        let zout_im = imag(zout)



        let s11w = maximum(s11db)

        let s21m = minimum(s21db)

        let s21x = maximum(s21db)

        let ripple = s21x-s21m

        let s22w = maximum(s22db)

        let nfw = maximum(nfdb)

        let mumin = minimum(mu)

        let mupmin = minimum(mup)

        let dmax = maximum(md)



        let s11c = s11db[25]

        let s21c = s21db[25]

        let s12c = s12db[25]

        let s22c = s22db[25]

        let nfc = nfdb[25]

        let zinrc = zin_re[25]

        let zinic = zin_im[25]

        let zoutrc = zout_re[25]

        let zoutic = zout_im[25]



        * ----- Formal score -----

        let penalty_gain = 0

        let penalty_nf = 0

        let penalty_ripple = 0

        let penalty_s11 = 0

        let penalty_s22 = 0

        let penalty_pdc = 0

        let penalty_mu = 0

        let penalty_mup = 0

        let penalty_delta = 0

        let passcount = 0



        if s21m < target_gain

          let penalty_gain = target_gain-s21m

        else

          let passcount = passcount+1

        end

        if nfw > target_nf

          let penalty_nf = nfw-target_nf

        else

          let passcount = passcount+1

        end

        if ripple > target_ripple

          let penalty_ripple = ripple-target_ripple

        else

          let passcount = passcount+1

        end

        if s11w > target_s11

          let penalty_s11 = s11w-target_s11

        else

          let passcount = passcount+1

        end

        if s22w > target_s22

          let penalty_s22 = s22w-target_s22

        else

          let passcount = passcount+1

        end

        if $op_pdc > target_pdc

          let penalty_pdc = $op_pdc-target_pdc

        else

          let passcount = passcount+1

        end

        if mumin < target_mu

          let penalty_mu = target_mu-mumin

        else

          let passcount = passcount+1

        end

        if mupmin < target_mu

          let penalty_mup = target_mu-mupmin

        else

          let passcount = passcount+1

        end

        if dmax >= target_delta

          let penalty_delta = dmax-target_delta+0.001

        else

          let passcount = passcount+1

        end



        let score = 320*penalty_gain+280*penalty_nf+180*penalty_ripple

        let score = score+35*penalty_s11+35*penalty_s22+2*penalty_pdc

        let score = score+300*penalty_mu+300*penalty_mup+600*penalty_delta

        let score = score+5*nfw-3*s21m+2*ripple+0.004*$op_pdc



        * Do not force very high gm; V20 showed capacitance can dominate.

        let penalty_gm3 = 0

        if $op_gm3 < 0.020

          let penalty_gm3 = 1000*(0.020-$op_gm3)

        end

        let score = score+5*penalty_gm3



        * Prefer a reasonably strong upper cascode without making it a hard RF constraint.

        let penalty_gm6 = 0

        if $op_gm6 < 0.015

          let penalty_gm6 = 1000*(0.015-$op_gm6)

        end

        let score = score+3*penalty_gm6



        * ----- Hard DC validity -----

        let dcvalid = 1

        if $op_pdc > target_pdc

          let dcvalid = 0

        end

        if $op_sat1 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat2 < min_satmargin_cg

          let dcvalid = 0

        end

        if $op_sat4 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat5 < min_satmargin_sink

          let dcvalid = 0

        end

        if $op_id5 < 0.0025

          let dcvalid = 0

        end

        if $op_id5 > 0.0060

          let dcvalid = 0

        end



        if $op_id3 < 0.008

          let dcvalid = 0

        end

        if $op_id3 > 0.030

          let dcvalid = 0

        end

        if $op_id6 < 0.008

          let dcvalid = 0

        end

        if $op_id6 > 0.030

          let dcvalid = 0

        end

        if $op_sat3 < min_satmargin_out_cs

          let dcvalid = 0

        end

        if $op_sat6 < min_satmargin_out_cas

          let dcvalid = 0

        end

        if $op_vs3 < 0

          let dcvalid = 0

        end

        if $op_vs3 > 0.50

          let dcvalid = 0

        end

        if $op_vx < 0.70

          let dcvalid = 0

        end

        if $op_vx > 2.30

          let dcvalid = 0

        end

        if $op_vout < 2.20

          let dcvalid = 0

        end

        if $op_vout > 4.50

          let dcvalid = 0

        end

        if $op_vout <= $op_vx

          let dcvalid = 0

        end

        if $op_vx <= $op_vs3

          let dcvalid = 0

        end



        let penalty_ratio = 0

        if $op_ratio25 < 3.0

          let penalty_ratio = 3.0-$op_ratio25

        end

        let penalty_gm5 = 0

        if $op_gm5 > 0.0065

          let penalty_gm5 = 1000*($op_gm5-0.0065)

        end

        let penalty_gds5 = 0

        if $op_gds5 > 0.0004

          let penalty_gds5 = 1000*($op_gds5-0.0004)

        end

        let score = score+30*penalty_ratio+10*penalty_gm5+20*penalty_gds5



        if dcvalid = 0

          let score = score+10000

        end



        let passall = 1

        if passcount < 9

          let passall = 0

        end

        if dcvalid = 0

          let passall = 0

        end



        echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo STAGE_A_POINT W3 $w3 W6 $w6 VB3 $vb3 VBCAS $vb6 RD $rdv RS 0.5 CS 100p COUT 33p CSHOUT
+ 1f LIN 2.0n >> lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo OP PDC_mW $op_pdc VSCG $op_vscg VDCG $op_vdcg NET7 $op_v7 NET8 $op_v8 GBUF $op_vg3
+ SOURCE3 $op_vs3 INTERNAL_X $op_vx OUTPUT_DC $op_vout XM1_ID $op_id1 XM1_GM $op_gm1 XM1_GDS $op_gds1 XM1_VDS
+ $op_vds1 XM1_VDSAT $op_vdsat1 XM1_MARGIN $op_sat1 XM2_ID $op_id2 XM2_GM $op_gm2 XM2_GMB $op_gmb2 XM2_GMEFF
+ $op_gm2eff XM2_GDS $op_gds2 XM2_VDS $op_vds2 XM2_VDSAT $op_vdsat2 XM2_MARGIN $op_sat2 XM3_ID $op_id3 XM3_GM
+ $op_gm3 XM3_GMB $op_gmb3 XM3_GDS $op_gds3 XM3_GMID $op_gmid3 XM3_VGS $op_vgs3 XM3_VDS $op_vds3 XM3_VDSAT
+ $op_vdsat3 XM3_MARGIN $op_sat3 XM3_RO $op_ro3 XM4_ID $op_id4 XM4_GM $op_gm4 XM4_GDS $op_gds4 XM4_VDS $op_vds4
+ XM4_VDSAT $op_vdsat4 XM4_MARGIN $op_sat4 XM5_ID $op_id5 XM5_GM $op_gm5 XM5_GDS $op_gds5 XM5_GMID $op_gmid5
+ XM5_VDS $op_vds5 XM5_VDSAT $op_vdsat5 XM5_MARGIN $op_sat5 XM5_RO $op_ro5 XM6_ID $op_id6 XM6_GM $op_gm6
+ XM6_GMB $op_gmb6 XM6_GDS $op_gds6 XM6_GMID $op_gmid6 XM6_VGS $op_vgs6 XM6_VDS $op_vds6 XM6_VDSAT $op_vdsat6
+ XM6_MARGIN $op_sat6 XM6_RO $op_ro6 GMEFF2_OVER_GM5 $op_ratio25 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo RF SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL $&passall S11W_dB
+ $&s11w S21MIN_dB $&s21m S21MAX_dB $&s21x RIPPLE_dB $&ripple S22W_dB $&s22w NFW_dB $&nfw MU_MIN $&mumin
+ MUP_MIN $&mupmin DELTA_MAX $&dmax AT_2P4 S11_dB $&s11c S21_dB $&s21c S12_dB $&s12c S22_dB $&s22c NF_dB
+ $&nfc ZIN_RE $&zinrc ZIN_IM $&zinic ZOUT_RE $&zoutrc ZOUT_IM $&zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



        echo $w3 $w6 $vb3 $vb6 $rdv $&score $&dcvalid $&passcount $&passall $op_pdc $op_vs3 $op_vx
+ $op_vout $op_id3 $op_gm3 $op_sat3 $op_id6 $op_gm6 $op_sat6 $&s11w $&s21m $&s21x $&ripple $&s22w $&nfw
+ $&mumin $&mupmin $&dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt



        if score < $A_best_score

  set A_best_score = $&score

  set A_best_w3 = $w3

  set A_best_w6 = $w6

  set A_best_vb3 = $vb3

  set A_best_vb6 = $vb6

  set A_best_rd = $rdv

  set A_best_passall = $&passall

end



        destroy $curplot



end

      end

    end

  end

end

echo STAGE_A_BEST SCORE $A_best_score W3 $A_best_w3 W6 $A_best_w6 VB3 $A_best_vb3 VBCAS $A_best_vb6
+ RD $A_best_rd PASSALL $A_best_passall >> lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* STAGE B — RD, COUT AND OUTPUT SHUNT CAPACITANCE

* 7 RD x 5 COUT x 6 CSHOUT = 210 points.

* =============================================================================

set B_best_score = 1e99

set B_best_rd = $A_best_rd

set B_best_cout = 33p

set B_best_cshout = 1f

set B_best_passall = 0



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_B_OUTPUT_LOAD_AND_MATCH >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo RD COUT CSHOUT SCORE DCVALID PASSCOUNT PASSALL PDC VX VOUT ID3 GM3 SAT3 ID6 GM6 SAT6 S11W
+ S21MIN S21MAX RIPPLE S22W NFW MU MUP DELTA >> lna_v22_cs_cascode_driver_corrected_summary.txt



foreach rdv 56 68 82 100 120 150 180

  foreach coutv 15p 22p 33p 47p 68p

    foreach cshoutv 1f 50f 100f 200f 300f 500f

      alterparam W_SF = $A_best_w3

      alterparam W_SF_CAS = $A_best_w6

      alterparam VBIAS_BUF = $A_best_vb3

      alterparam VBIAS_CAS_BUF = $A_best_vb6

      alterparam RD_OUT = $rdv

      alterparam RS_OUT = 0.5

      alterparam CSOUT_VAL = 100p

      alterparam COUT_VAL = $coutv

      alterparam C_SH_OUT = $cshoutv

      alterparam L_IN = 2.0n

      alterparam C_SH_IN = 1f



reset

        op



        * ----- DC operating point -----

        let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

        let vscgop = v(s)

        let vdcgop = v(d)

        let v7op = v(net7)

        let v8op = v(net8)

        let vg3op = v(g_buf)

        let vs3op = v(net3)

        let vxop = v(net9)

        let voutop = v(vbuf)



        let id1op = abs(@m.xm1.m0[id])

        let gm1op = @m.xm1.m0[gm]

        let gds1op = @m.xm1.m0[gds]

        let vds1op = v(net7)

        let vdsat1op = abs(@m.xm1.m0[vdsat])

        let sat1op = vds1op-vdsat1op



        let id2op = abs(@m.xm2.m0[id])

        let gm2op = @m.xm2.m0[gm]

        let gmb2op = @m.xm2.m0[gmbs]

        let gm2effop = gm2op+gmb2op

        let gds2op = @m.xm2.m0[gds]

        let vds2op = v(d)-v(s)

        let vdsat2op = abs(@m.xm2.m0[vdsat])

        let sat2op = vds2op-vdsat2op



        let id3op = abs(@m.xm3.m0[id])

        let gm3op = @m.xm3.m0[gm]

        let gmb3op = @m.xm3.m0[gmbs]

        let gds3op = @m.xm3.m0[gds]

        let gmid3op = gm3op/id3op

        let vgs3op = v(g_buf)-v(net3)

        let vds3op = v(net9)-v(net3)

        let vdsat3op = abs(@m.xm3.m0[vdsat])

        let sat3op = vds3op-vdsat3op

        let ro3op = 1/gds3op



        let id4op = abs(@m.xm4.m0[id])

        let gm4op = @m.xm4.m0[gm]

        let gds4op = @m.xm4.m0[gds]

        let vds4op = v(net8)-v(net7)

        let vdsat4op = abs(@m.xm4.m0[vdsat])

        let sat4op = vds4op-vdsat4op



        let id5op = abs(@m.xm5.m0[id])

        let gm5op = @m.xm5.m0[gm]

        let gds5op = @m.xm5.m0[gds]

        let gmid5op = gm5op/id5op

        let vds5op = v(s)

        let vdsat5op = abs(@m.xm5.m0[vdsat])

        let sat5op = vds5op-vdsat5op

        let ro5op = 1/gds5op



        let id6op = abs(@m.xm6.m0[id])

        let gm6op = @m.xm6.m0[gm]

        let gmb6op = @m.xm6.m0[gmbs]

        let gds6op = @m.xm6.m0[gds]

        let gmid6op = gm6op/id6op

        let vgs6op = v(vbias_cas_buf)-v(net9)

        let vds6op = v(vbuf)-v(net9)

        let vdsat6op = abs(@m.xm6.m0[vdsat])

        let sat6op = vds6op-vdsat6op

        let ro6op = 1/gds6op



        let ratio25op = gm2effop/gm5op



        set op_pdc = $&pdcop

        set op_vscg = $&vscgop

        set op_vdcg = $&vdcgop

        set op_v7 = $&v7op

        set op_v8 = $&v8op

        set op_vg3 = $&vg3op

        set op_vs3 = $&vs3op

        set op_vx = $&vxop

        set op_vout = $&voutop



        set op_id1 = $&id1op

        set op_gm1 = $&gm1op

        set op_gds1 = $&gds1op

        set op_vds1 = $&vds1op

        set op_vdsat1 = $&vdsat1op

        set op_sat1 = $&sat1op



        set op_id2 = $&id2op

        set op_gm2 = $&gm2op

        set op_gmb2 = $&gmb2op

        set op_gm2eff = $&gm2effop

        set op_gds2 = $&gds2op

        set op_vds2 = $&vds2op

        set op_vdsat2 = $&vdsat2op

        set op_sat2 = $&sat2op



        set op_id3 = $&id3op

        set op_gm3 = $&gm3op

        set op_gmb3 = $&gmb3op

        set op_gds3 = $&gds3op

        set op_gmid3 = $&gmid3op

        set op_vgs3 = $&vgs3op

        set op_vds3 = $&vds3op

        set op_vdsat3 = $&vdsat3op

        set op_sat3 = $&sat3op

        set op_ro3 = $&ro3op



        set op_id4 = $&id4op

        set op_gm4 = $&gm4op

        set op_gds4 = $&gds4op

        set op_vds4 = $&vds4op

        set op_vdsat4 = $&vdsat4op

        set op_sat4 = $&sat4op



        set op_id5 = $&id5op

        set op_gm5 = $&gm5op

        set op_gds5 = $&gds5op

        set op_gmid5 = $&gmid5op

        set op_vds5 = $&vds5op

        set op_vdsat5 = $&vdsat5op

        set op_sat5 = $&sat5op

        set op_ro5 = $&ro5op



        set op_id6 = $&id6op

        set op_gm6 = $&gm6op

        set op_gmb6 = $&gmb6op

        set op_gds6 = $&gds6op

        set op_gmid6 = $&gmid6op

        set op_vgs6 = $&vgs6op

        set op_vds6 = $&vds6op

        set op_vdsat6 = $&vdsat6op

        set op_sat6 = $&sat6op

        set op_ro6 = $&ro6op

        set op_ratio25 = $&ratio25op



        destroy $curplot



        * ----- RF/noise/stability over target band -----

        sp lin 51 2.30G 2.50G 1

        let s11db = db(s_1_1)

        let s21db = db(s_2_1)

        let s12db = db(s_1_2)

        let s22db = db(s_2_2)

        let nfdb = real(NF)



        let delta = s_1_1*s_2_2-s_1_2*s_2_1

        let md = mag(delta)

        let a11 = mag(s_1_1)

        let a12 = mag(s_1_2)

        let a21 = mag(s_2_1)

        let a22 = mag(s_2_2)

        let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))

        let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

        let kval = (1-a11*a11-a22*a22+md*md)/(2*a12*a21)



        let zin = 50*(1+s_1_1)/(1-s_1_1)

        let zout = 50*(1+s_2_2)/(1-s_2_2)

        let zin_re = real(zin)

        let zin_im = imag(zin)

        let zout_re = real(zout)

        let zout_im = imag(zout)



        let s11w = maximum(s11db)

        let s21m = minimum(s21db)

        let s21x = maximum(s21db)

        let ripple = s21x-s21m

        let s22w = maximum(s22db)

        let nfw = maximum(nfdb)

        let mumin = minimum(mu)

        let mupmin = minimum(mup)

        let dmax = maximum(md)



        let s11c = s11db[25]

        let s21c = s21db[25]

        let s12c = s12db[25]

        let s22c = s22db[25]

        let nfc = nfdb[25]

        let zinrc = zin_re[25]

        let zinic = zin_im[25]

        let zoutrc = zout_re[25]

        let zoutic = zout_im[25]



        * ----- Formal score -----

        let penalty_gain = 0

        let penalty_nf = 0

        let penalty_ripple = 0

        let penalty_s11 = 0

        let penalty_s22 = 0

        let penalty_pdc = 0

        let penalty_mu = 0

        let penalty_mup = 0

        let penalty_delta = 0

        let passcount = 0



        if s21m < target_gain

          let penalty_gain = target_gain-s21m

        else

          let passcount = passcount+1

        end

        if nfw > target_nf

          let penalty_nf = nfw-target_nf

        else

          let passcount = passcount+1

        end

        if ripple > target_ripple

          let penalty_ripple = ripple-target_ripple

        else

          let passcount = passcount+1

        end

        if s11w > target_s11

          let penalty_s11 = s11w-target_s11

        else

          let passcount = passcount+1

        end

        if s22w > target_s22

          let penalty_s22 = s22w-target_s22

        else

          let passcount = passcount+1

        end

        if $op_pdc > target_pdc

          let penalty_pdc = $op_pdc-target_pdc

        else

          let passcount = passcount+1

        end

        if mumin < target_mu

          let penalty_mu = target_mu-mumin

        else

          let passcount = passcount+1

        end

        if mupmin < target_mu

          let penalty_mup = target_mu-mupmin

        else

          let passcount = passcount+1

        end

        if dmax >= target_delta

          let penalty_delta = dmax-target_delta+0.001

        else

          let passcount = passcount+1

        end



        let score = 320*penalty_gain+280*penalty_nf+180*penalty_ripple

        let score = score+35*penalty_s11+35*penalty_s22+2*penalty_pdc

        let score = score+300*penalty_mu+300*penalty_mup+600*penalty_delta

        let score = score+5*nfw-3*s21m+2*ripple+0.004*$op_pdc



        * Do not force very high gm; V20 showed capacitance can dominate.

        let penalty_gm3 = 0

        if $op_gm3 < 0.020

          let penalty_gm3 = 1000*(0.020-$op_gm3)

        end

        let score = score+5*penalty_gm3



        * Prefer a reasonably strong upper cascode without making it a hard RF constraint.

        let penalty_gm6 = 0

        if $op_gm6 < 0.015

          let penalty_gm6 = 1000*(0.015-$op_gm6)

        end

        let score = score+3*penalty_gm6



        * ----- Hard DC validity -----

        let dcvalid = 1

        if $op_pdc > target_pdc

          let dcvalid = 0

        end

        if $op_sat1 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat2 < min_satmargin_cg

          let dcvalid = 0

        end

        if $op_sat4 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat5 < min_satmargin_sink

          let dcvalid = 0

        end

        if $op_id5 < 0.0025

          let dcvalid = 0

        end

        if $op_id5 > 0.0060

          let dcvalid = 0

        end



        if $op_id3 < 0.008

          let dcvalid = 0

        end

        if $op_id3 > 0.030

          let dcvalid = 0

        end

        if $op_id6 < 0.008

          let dcvalid = 0

        end

        if $op_id6 > 0.030

          let dcvalid = 0

        end

        if $op_sat3 < min_satmargin_out_cs

          let dcvalid = 0

        end

        if $op_sat6 < min_satmargin_out_cas

          let dcvalid = 0

        end

        if $op_vs3 < 0

          let dcvalid = 0

        end

        if $op_vs3 > 0.50

          let dcvalid = 0

        end

        if $op_vx < 0.70

          let dcvalid = 0

        end

        if $op_vx > 2.30

          let dcvalid = 0

        end

        if $op_vout < 2.20

          let dcvalid = 0

        end

        if $op_vout > 4.50

          let dcvalid = 0

        end

        if $op_vout <= $op_vx

          let dcvalid = 0

        end

        if $op_vx <= $op_vs3

          let dcvalid = 0

        end



        let penalty_ratio = 0

        if $op_ratio25 < 3.0

          let penalty_ratio = 3.0-$op_ratio25

        end

        let penalty_gm5 = 0

        if $op_gm5 > 0.0065

          let penalty_gm5 = 1000*($op_gm5-0.0065)

        end

        let penalty_gds5 = 0

        if $op_gds5 > 0.0004

          let penalty_gds5 = 1000*($op_gds5-0.0004)

        end

        let score = score+30*penalty_ratio+10*penalty_gm5+20*penalty_gds5



        if dcvalid = 0

          let score = score+10000

        end



        let passall = 1

        if passcount < 9

          let passall = 0

        end

        if dcvalid = 0

          let passall = 0

        end



        echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo STAGE_B_POINT RD $rdv COUT $coutv CSHOUT $cshoutv W3 $A_best_w3 W6 $A_best_w6 VB3
+ $A_best_vb3 VBCAS $A_best_vb6 >> lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo OP PDC_mW $op_pdc VSCG $op_vscg VDCG $op_vdcg NET7 $op_v7 NET8 $op_v8 GBUF $op_vg3
+ SOURCE3 $op_vs3 INTERNAL_X $op_vx OUTPUT_DC $op_vout XM1_ID $op_id1 XM1_GM $op_gm1 XM1_GDS $op_gds1 XM1_VDS
+ $op_vds1 XM1_VDSAT $op_vdsat1 XM1_MARGIN $op_sat1 XM2_ID $op_id2 XM2_GM $op_gm2 XM2_GMB $op_gmb2 XM2_GMEFF
+ $op_gm2eff XM2_GDS $op_gds2 XM2_VDS $op_vds2 XM2_VDSAT $op_vdsat2 XM2_MARGIN $op_sat2 XM3_ID $op_id3 XM3_GM
+ $op_gm3 XM3_GMB $op_gmb3 XM3_GDS $op_gds3 XM3_GMID $op_gmid3 XM3_VGS $op_vgs3 XM3_VDS $op_vds3 XM3_VDSAT
+ $op_vdsat3 XM3_MARGIN $op_sat3 XM3_RO $op_ro3 XM4_ID $op_id4 XM4_GM $op_gm4 XM4_GDS $op_gds4 XM4_VDS $op_vds4
+ XM4_VDSAT $op_vdsat4 XM4_MARGIN $op_sat4 XM5_ID $op_id5 XM5_GM $op_gm5 XM5_GDS $op_gds5 XM5_GMID $op_gmid5
+ XM5_VDS $op_vds5 XM5_VDSAT $op_vdsat5 XM5_MARGIN $op_sat5 XM5_RO $op_ro5 XM6_ID $op_id6 XM6_GM $op_gm6
+ XM6_GMB $op_gmb6 XM6_GDS $op_gds6 XM6_GMID $op_gmid6 XM6_VGS $op_vgs6 XM6_VDS $op_vds6 XM6_VDSAT $op_vdsat6
+ XM6_MARGIN $op_sat6 XM6_RO $op_ro6 GMEFF2_OVER_GM5 $op_ratio25 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo RF SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL $&passall S11W_dB
+ $&s11w S21MIN_dB $&s21m S21MAX_dB $&s21x RIPPLE_dB $&ripple S22W_dB $&s22w NFW_dB $&nfw MU_MIN $&mumin
+ MUP_MIN $&mupmin DELTA_MAX $&dmax AT_2P4 S11_dB $&s11c S21_dB $&s21c S12_dB $&s12c S22_dB $&s22c NF_dB
+ $&nfc ZIN_RE $&zinrc ZIN_IM $&zinic ZOUT_RE $&zoutrc ZOUT_IM $&zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



        echo $rdv $coutv $cshoutv $&score $&dcvalid $&passcount $&passall $op_pdc $op_vx $op_vout
+ $op_id3 $op_gm3 $op_sat3 $op_id6 $op_gm6 $op_sat6 $&s11w $&s21m $&s21x $&ripple $&s22w $&nfw $&mumin
+ $&mupmin $&dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt



        if score < $B_best_score

  set B_best_score = $&score

  set B_best_rd = $rdv

  set B_best_cout = $coutv

  set B_best_cshout = $cshoutv

  set B_best_passall = $&passall

end



        destroy $curplot



end

  end

end

echo STAGE_B_BEST SCORE $B_best_score RD $B_best_rd COUT $B_best_cout CSHOUT $B_best_cshout PASSALL
+ $B_best_passall >> lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* STAGE C — SOURCE RC EQUALIZATION

* 5 RS x 7 CS = 35 points.

* =============================================================================

set C_best_score = 1e99

set C_best_rs = 0.5

set C_best_cs = 100p

set C_best_passall = 0



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_C_SOURCE_RC_EQUALIZATION >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo RS CS SCORE DCVALID PASSCOUNT PASSALL PDC VS3 VX VOUT ID3 GM3 SAT3 ID6 GM6 SAT6 S11W S21MIN
+ S21MAX RIPPLE S22W NFW MU MUP DELTA >> lna_v22_cs_cascode_driver_corrected_summary.txt



foreach rsv 0.5 2 5 10 15

  foreach csv 2.2p 3.3p 4.7p 6.8p 10p 15p 100p

    alterparam W_SF = $A_best_w3

    alterparam W_SF_CAS = $A_best_w6

    alterparam VBIAS_BUF = $A_best_vb3

    alterparam VBIAS_CAS_BUF = $A_best_vb6

    alterparam RD_OUT = $B_best_rd

    alterparam RS_OUT = $rsv

    alterparam CSOUT_VAL = $csv

    alterparam COUT_VAL = $B_best_cout

    alterparam C_SH_OUT = $B_best_cshout

    alterparam L_IN = 2.0n

    alterparam C_SH_IN = 1f



reset

        op



        * ----- DC operating point -----

        let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

        let vscgop = v(s)

        let vdcgop = v(d)

        let v7op = v(net7)

        let v8op = v(net8)

        let vg3op = v(g_buf)

        let vs3op = v(net3)

        let vxop = v(net9)

        let voutop = v(vbuf)



        let id1op = abs(@m.xm1.m0[id])

        let gm1op = @m.xm1.m0[gm]

        let gds1op = @m.xm1.m0[gds]

        let vds1op = v(net7)

        let vdsat1op = abs(@m.xm1.m0[vdsat])

        let sat1op = vds1op-vdsat1op



        let id2op = abs(@m.xm2.m0[id])

        let gm2op = @m.xm2.m0[gm]

        let gmb2op = @m.xm2.m0[gmbs]

        let gm2effop = gm2op+gmb2op

        let gds2op = @m.xm2.m0[gds]

        let vds2op = v(d)-v(s)

        let vdsat2op = abs(@m.xm2.m0[vdsat])

        let sat2op = vds2op-vdsat2op



        let id3op = abs(@m.xm3.m0[id])

        let gm3op = @m.xm3.m0[gm]

        let gmb3op = @m.xm3.m0[gmbs]

        let gds3op = @m.xm3.m0[gds]

        let gmid3op = gm3op/id3op

        let vgs3op = v(g_buf)-v(net3)

        let vds3op = v(net9)-v(net3)

        let vdsat3op = abs(@m.xm3.m0[vdsat])

        let sat3op = vds3op-vdsat3op

        let ro3op = 1/gds3op



        let id4op = abs(@m.xm4.m0[id])

        let gm4op = @m.xm4.m0[gm]

        let gds4op = @m.xm4.m0[gds]

        let vds4op = v(net8)-v(net7)

        let vdsat4op = abs(@m.xm4.m0[vdsat])

        let sat4op = vds4op-vdsat4op



        let id5op = abs(@m.xm5.m0[id])

        let gm5op = @m.xm5.m0[gm]

        let gds5op = @m.xm5.m0[gds]

        let gmid5op = gm5op/id5op

        let vds5op = v(s)

        let vdsat5op = abs(@m.xm5.m0[vdsat])

        let sat5op = vds5op-vdsat5op

        let ro5op = 1/gds5op



        let id6op = abs(@m.xm6.m0[id])

        let gm6op = @m.xm6.m0[gm]

        let gmb6op = @m.xm6.m0[gmbs]

        let gds6op = @m.xm6.m0[gds]

        let gmid6op = gm6op/id6op

        let vgs6op = v(vbias_cas_buf)-v(net9)

        let vds6op = v(vbuf)-v(net9)

        let vdsat6op = abs(@m.xm6.m0[vdsat])

        let sat6op = vds6op-vdsat6op

        let ro6op = 1/gds6op



        let ratio25op = gm2effop/gm5op



        set op_pdc = $&pdcop

        set op_vscg = $&vscgop

        set op_vdcg = $&vdcgop

        set op_v7 = $&v7op

        set op_v8 = $&v8op

        set op_vg3 = $&vg3op

        set op_vs3 = $&vs3op

        set op_vx = $&vxop

        set op_vout = $&voutop



        set op_id1 = $&id1op

        set op_gm1 = $&gm1op

        set op_gds1 = $&gds1op

        set op_vds1 = $&vds1op

        set op_vdsat1 = $&vdsat1op

        set op_sat1 = $&sat1op



        set op_id2 = $&id2op

        set op_gm2 = $&gm2op

        set op_gmb2 = $&gmb2op

        set op_gm2eff = $&gm2effop

        set op_gds2 = $&gds2op

        set op_vds2 = $&vds2op

        set op_vdsat2 = $&vdsat2op

        set op_sat2 = $&sat2op



        set op_id3 = $&id3op

        set op_gm3 = $&gm3op

        set op_gmb3 = $&gmb3op

        set op_gds3 = $&gds3op

        set op_gmid3 = $&gmid3op

        set op_vgs3 = $&vgs3op

        set op_vds3 = $&vds3op

        set op_vdsat3 = $&vdsat3op

        set op_sat3 = $&sat3op

        set op_ro3 = $&ro3op



        set op_id4 = $&id4op

        set op_gm4 = $&gm4op

        set op_gds4 = $&gds4op

        set op_vds4 = $&vds4op

        set op_vdsat4 = $&vdsat4op

        set op_sat4 = $&sat4op



        set op_id5 = $&id5op

        set op_gm5 = $&gm5op

        set op_gds5 = $&gds5op

        set op_gmid5 = $&gmid5op

        set op_vds5 = $&vds5op

        set op_vdsat5 = $&vdsat5op

        set op_sat5 = $&sat5op

        set op_ro5 = $&ro5op



        set op_id6 = $&id6op

        set op_gm6 = $&gm6op

        set op_gmb6 = $&gmb6op

        set op_gds6 = $&gds6op

        set op_gmid6 = $&gmid6op

        set op_vgs6 = $&vgs6op

        set op_vds6 = $&vds6op

        set op_vdsat6 = $&vdsat6op

        set op_sat6 = $&sat6op

        set op_ro6 = $&ro6op

        set op_ratio25 = $&ratio25op



        destroy $curplot



        * ----- RF/noise/stability over target band -----

        sp lin 51 2.30G 2.50G 1

        let s11db = db(s_1_1)

        let s21db = db(s_2_1)

        let s12db = db(s_1_2)

        let s22db = db(s_2_2)

        let nfdb = real(NF)



        let delta = s_1_1*s_2_2-s_1_2*s_2_1

        let md = mag(delta)

        let a11 = mag(s_1_1)

        let a12 = mag(s_1_2)

        let a21 = mag(s_2_1)

        let a22 = mag(s_2_2)

        let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))

        let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

        let kval = (1-a11*a11-a22*a22+md*md)/(2*a12*a21)



        let zin = 50*(1+s_1_1)/(1-s_1_1)

        let zout = 50*(1+s_2_2)/(1-s_2_2)

        let zin_re = real(zin)

        let zin_im = imag(zin)

        let zout_re = real(zout)

        let zout_im = imag(zout)



        let s11w = maximum(s11db)

        let s21m = minimum(s21db)

        let s21x = maximum(s21db)

        let ripple = s21x-s21m

        let s22w = maximum(s22db)

        let nfw = maximum(nfdb)

        let mumin = minimum(mu)

        let mupmin = minimum(mup)

        let dmax = maximum(md)



        let s11c = s11db[25]

        let s21c = s21db[25]

        let s12c = s12db[25]

        let s22c = s22db[25]

        let nfc = nfdb[25]

        let zinrc = zin_re[25]

        let zinic = zin_im[25]

        let zoutrc = zout_re[25]

        let zoutic = zout_im[25]



        * ----- Formal score -----

        let penalty_gain = 0

        let penalty_nf = 0

        let penalty_ripple = 0

        let penalty_s11 = 0

        let penalty_s22 = 0

        let penalty_pdc = 0

        let penalty_mu = 0

        let penalty_mup = 0

        let penalty_delta = 0

        let passcount = 0



        if s21m < target_gain

          let penalty_gain = target_gain-s21m

        else

          let passcount = passcount+1

        end

        if nfw > target_nf

          let penalty_nf = nfw-target_nf

        else

          let passcount = passcount+1

        end

        if ripple > target_ripple

          let penalty_ripple = ripple-target_ripple

        else

          let passcount = passcount+1

        end

        if s11w > target_s11

          let penalty_s11 = s11w-target_s11

        else

          let passcount = passcount+1

        end

        if s22w > target_s22

          let penalty_s22 = s22w-target_s22

        else

          let passcount = passcount+1

        end

        if $op_pdc > target_pdc

          let penalty_pdc = $op_pdc-target_pdc

        else

          let passcount = passcount+1

        end

        if mumin < target_mu

          let penalty_mu = target_mu-mumin

        else

          let passcount = passcount+1

        end

        if mupmin < target_mu

          let penalty_mup = target_mu-mupmin

        else

          let passcount = passcount+1

        end

        if dmax >= target_delta

          let penalty_delta = dmax-target_delta+0.001

        else

          let passcount = passcount+1

        end



        let score = 320*penalty_gain+280*penalty_nf+180*penalty_ripple

        let score = score+35*penalty_s11+35*penalty_s22+2*penalty_pdc

        let score = score+300*penalty_mu+300*penalty_mup+600*penalty_delta

        let score = score+5*nfw-3*s21m+2*ripple+0.004*$op_pdc



        * Do not force very high gm; V20 showed capacitance can dominate.

        let penalty_gm3 = 0

        if $op_gm3 < 0.020

          let penalty_gm3 = 1000*(0.020-$op_gm3)

        end

        let score = score+5*penalty_gm3



        * Prefer a reasonably strong upper cascode without making it a hard RF constraint.

        let penalty_gm6 = 0

        if $op_gm6 < 0.015

          let penalty_gm6 = 1000*(0.015-$op_gm6)

        end

        let score = score+3*penalty_gm6



        * ----- Hard DC validity -----

        let dcvalid = 1

        if $op_pdc > target_pdc

          let dcvalid = 0

        end

        if $op_sat1 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat2 < min_satmargin_cg

          let dcvalid = 0

        end

        if $op_sat4 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat5 < min_satmargin_sink

          let dcvalid = 0

        end

        if $op_id5 < 0.0025

          let dcvalid = 0

        end

        if $op_id5 > 0.0060

          let dcvalid = 0

        end



        if $op_id3 < 0.008

          let dcvalid = 0

        end

        if $op_id3 > 0.030

          let dcvalid = 0

        end

        if $op_id6 < 0.008

          let dcvalid = 0

        end

        if $op_id6 > 0.030

          let dcvalid = 0

        end

        if $op_sat3 < min_satmargin_out_cs

          let dcvalid = 0

        end

        if $op_sat6 < min_satmargin_out_cas

          let dcvalid = 0

        end

        if $op_vs3 < 0

          let dcvalid = 0

        end

        if $op_vs3 > 0.50

          let dcvalid = 0

        end

        if $op_vx < 0.70

          let dcvalid = 0

        end

        if $op_vx > 2.30

          let dcvalid = 0

        end

        if $op_vout < 2.20

          let dcvalid = 0

        end

        if $op_vout > 4.50

          let dcvalid = 0

        end

        if $op_vout <= $op_vx

          let dcvalid = 0

        end

        if $op_vx <= $op_vs3

          let dcvalid = 0

        end



        let penalty_ratio = 0

        if $op_ratio25 < 3.0

          let penalty_ratio = 3.0-$op_ratio25

        end

        let penalty_gm5 = 0

        if $op_gm5 > 0.0065

          let penalty_gm5 = 1000*($op_gm5-0.0065)

        end

        let penalty_gds5 = 0

        if $op_gds5 > 0.0004

          let penalty_gds5 = 1000*($op_gds5-0.0004)

        end

        let score = score+30*penalty_ratio+10*penalty_gm5+20*penalty_gds5



        if dcvalid = 0

          let score = score+10000

        end



        let passall = 1

        if passcount < 9

          let passall = 0

        end

        if dcvalid = 0

          let passall = 0

        end



        echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo STAGE_C_POINT RS $rsv CS $csv RD $B_best_rd COUT $B_best_cout CSHOUT $B_best_cshout >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo OP PDC_mW $op_pdc VSCG $op_vscg VDCG $op_vdcg NET7 $op_v7 NET8 $op_v8 GBUF $op_vg3
+ SOURCE3 $op_vs3 INTERNAL_X $op_vx OUTPUT_DC $op_vout XM1_ID $op_id1 XM1_GM $op_gm1 XM1_GDS $op_gds1 XM1_VDS
+ $op_vds1 XM1_VDSAT $op_vdsat1 XM1_MARGIN $op_sat1 XM2_ID $op_id2 XM2_GM $op_gm2 XM2_GMB $op_gmb2 XM2_GMEFF
+ $op_gm2eff XM2_GDS $op_gds2 XM2_VDS $op_vds2 XM2_VDSAT $op_vdsat2 XM2_MARGIN $op_sat2 XM3_ID $op_id3 XM3_GM
+ $op_gm3 XM3_GMB $op_gmb3 XM3_GDS $op_gds3 XM3_GMID $op_gmid3 XM3_VGS $op_vgs3 XM3_VDS $op_vds3 XM3_VDSAT
+ $op_vdsat3 XM3_MARGIN $op_sat3 XM3_RO $op_ro3 XM4_ID $op_id4 XM4_GM $op_gm4 XM4_GDS $op_gds4 XM4_VDS $op_vds4
+ XM4_VDSAT $op_vdsat4 XM4_MARGIN $op_sat4 XM5_ID $op_id5 XM5_GM $op_gm5 XM5_GDS $op_gds5 XM5_GMID $op_gmid5
+ XM5_VDS $op_vds5 XM5_VDSAT $op_vdsat5 XM5_MARGIN $op_sat5 XM5_RO $op_ro5 XM6_ID $op_id6 XM6_GM $op_gm6
+ XM6_GMB $op_gmb6 XM6_GDS $op_gds6 XM6_GMID $op_gmid6 XM6_VGS $op_vgs6 XM6_VDS $op_vds6 XM6_VDSAT $op_vdsat6
+ XM6_MARGIN $op_sat6 XM6_RO $op_ro6 GMEFF2_OVER_GM5 $op_ratio25 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo RF SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL $&passall S11W_dB
+ $&s11w S21MIN_dB $&s21m S21MAX_dB $&s21x RIPPLE_dB $&ripple S22W_dB $&s22w NFW_dB $&nfw MU_MIN $&mumin
+ MUP_MIN $&mupmin DELTA_MAX $&dmax AT_2P4 S11_dB $&s11c S21_dB $&s21c S12_dB $&s12c S22_dB $&s22c NF_dB
+ $&nfc ZIN_RE $&zinrc ZIN_IM $&zinic ZOUT_RE $&zoutrc ZOUT_IM $&zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



        echo $rsv $csv $&score $&dcvalid $&passcount $&passall $op_pdc $op_vs3 $op_vx $op_vout
+ $op_id3 $op_gm3 $op_sat3 $op_id6 $op_gm6 $op_sat6 $&s11w $&s21m $&s21x $&ripple $&s22w $&nfw $&mumin
+ $&mupmin $&dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt



        if score < $C_best_score

  set C_best_score = $&score

  set C_best_rs = $rsv

  set C_best_cs = $csv

  set C_best_passall = $&passall

end



        destroy $curplot



end

end

echo STAGE_C_BEST SCORE $C_best_score RS $C_best_rs CS $C_best_cs PASSALL $C_best_passall >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* STAGE D — INPUT MATCH, MAXIMUM INTENTIONAL L = 2 nH

* 6 LIN x 4 CSHIN = 24 points.

* =============================================================================

set D_best_score = 1e99

set D_best_lin = 2.0n

set D_best_cshin = 1f

set D_best_passall = 0



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_D_INPUT_MATCH >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo LIN CSHIN SCORE DCVALID PASSCOUNT PASSALL PDC S11W S21MIN S21MAX RIPPLE S22W NFW MU MUP DELTA
+ >> lna_v22_cs_cascode_driver_corrected_summary.txt



foreach linv 1.0n 1.2n 1.4n 1.6n 1.8n 2.0n

  foreach cshinv 1f 50f 100f 200f

    alterparam W_SF = $A_best_w3

    alterparam W_SF_CAS = $A_best_w6

    alterparam VBIAS_BUF = $A_best_vb3

    alterparam VBIAS_CAS_BUF = $A_best_vb6

    alterparam RD_OUT = $B_best_rd

    alterparam RS_OUT = $C_best_rs

    alterparam CSOUT_VAL = $C_best_cs

    alterparam COUT_VAL = $B_best_cout

    alterparam C_SH_OUT = $B_best_cshout

    alterparam L_IN = $linv

    alterparam C_SH_IN = $cshinv



reset

        op



        * ----- DC operating point -----

        let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

        let vscgop = v(s)

        let vdcgop = v(d)

        let v7op = v(net7)

        let v8op = v(net8)

        let vg3op = v(g_buf)

        let vs3op = v(net3)

        let vxop = v(net9)

        let voutop = v(vbuf)



        let id1op = abs(@m.xm1.m0[id])

        let gm1op = @m.xm1.m0[gm]

        let gds1op = @m.xm1.m0[gds]

        let vds1op = v(net7)

        let vdsat1op = abs(@m.xm1.m0[vdsat])

        let sat1op = vds1op-vdsat1op



        let id2op = abs(@m.xm2.m0[id])

        let gm2op = @m.xm2.m0[gm]

        let gmb2op = @m.xm2.m0[gmbs]

        let gm2effop = gm2op+gmb2op

        let gds2op = @m.xm2.m0[gds]

        let vds2op = v(d)-v(s)

        let vdsat2op = abs(@m.xm2.m0[vdsat])

        let sat2op = vds2op-vdsat2op



        let id3op = abs(@m.xm3.m0[id])

        let gm3op = @m.xm3.m0[gm]

        let gmb3op = @m.xm3.m0[gmbs]

        let gds3op = @m.xm3.m0[gds]

        let gmid3op = gm3op/id3op

        let vgs3op = v(g_buf)-v(net3)

        let vds3op = v(net9)-v(net3)

        let vdsat3op = abs(@m.xm3.m0[vdsat])

        let sat3op = vds3op-vdsat3op

        let ro3op = 1/gds3op



        let id4op = abs(@m.xm4.m0[id])

        let gm4op = @m.xm4.m0[gm]

        let gds4op = @m.xm4.m0[gds]

        let vds4op = v(net8)-v(net7)

        let vdsat4op = abs(@m.xm4.m0[vdsat])

        let sat4op = vds4op-vdsat4op



        let id5op = abs(@m.xm5.m0[id])

        let gm5op = @m.xm5.m0[gm]

        let gds5op = @m.xm5.m0[gds]

        let gmid5op = gm5op/id5op

        let vds5op = v(s)

        let vdsat5op = abs(@m.xm5.m0[vdsat])

        let sat5op = vds5op-vdsat5op

        let ro5op = 1/gds5op



        let id6op = abs(@m.xm6.m0[id])

        let gm6op = @m.xm6.m0[gm]

        let gmb6op = @m.xm6.m0[gmbs]

        let gds6op = @m.xm6.m0[gds]

        let gmid6op = gm6op/id6op

        let vgs6op = v(vbias_cas_buf)-v(net9)

        let vds6op = v(vbuf)-v(net9)

        let vdsat6op = abs(@m.xm6.m0[vdsat])

        let sat6op = vds6op-vdsat6op

        let ro6op = 1/gds6op



        let ratio25op = gm2effop/gm5op



        set op_pdc = $&pdcop

        set op_vscg = $&vscgop

        set op_vdcg = $&vdcgop

        set op_v7 = $&v7op

        set op_v8 = $&v8op

        set op_vg3 = $&vg3op

        set op_vs3 = $&vs3op

        set op_vx = $&vxop

        set op_vout = $&voutop



        set op_id1 = $&id1op

        set op_gm1 = $&gm1op

        set op_gds1 = $&gds1op

        set op_vds1 = $&vds1op

        set op_vdsat1 = $&vdsat1op

        set op_sat1 = $&sat1op



        set op_id2 = $&id2op

        set op_gm2 = $&gm2op

        set op_gmb2 = $&gmb2op

        set op_gm2eff = $&gm2effop

        set op_gds2 = $&gds2op

        set op_vds2 = $&vds2op

        set op_vdsat2 = $&vdsat2op

        set op_sat2 = $&sat2op



        set op_id3 = $&id3op

        set op_gm3 = $&gm3op

        set op_gmb3 = $&gmb3op

        set op_gds3 = $&gds3op

        set op_gmid3 = $&gmid3op

        set op_vgs3 = $&vgs3op

        set op_vds3 = $&vds3op

        set op_vdsat3 = $&vdsat3op

        set op_sat3 = $&sat3op

        set op_ro3 = $&ro3op



        set op_id4 = $&id4op

        set op_gm4 = $&gm4op

        set op_gds4 = $&gds4op

        set op_vds4 = $&vds4op

        set op_vdsat4 = $&vdsat4op

        set op_sat4 = $&sat4op



        set op_id5 = $&id5op

        set op_gm5 = $&gm5op

        set op_gds5 = $&gds5op

        set op_gmid5 = $&gmid5op

        set op_vds5 = $&vds5op

        set op_vdsat5 = $&vdsat5op

        set op_sat5 = $&sat5op

        set op_ro5 = $&ro5op



        set op_id6 = $&id6op

        set op_gm6 = $&gm6op

        set op_gmb6 = $&gmb6op

        set op_gds6 = $&gds6op

        set op_gmid6 = $&gmid6op

        set op_vgs6 = $&vgs6op

        set op_vds6 = $&vds6op

        set op_vdsat6 = $&vdsat6op

        set op_sat6 = $&sat6op

        set op_ro6 = $&ro6op

        set op_ratio25 = $&ratio25op



        destroy $curplot



        * ----- RF/noise/stability over target band -----

        sp lin 51 2.30G 2.50G 1

        let s11db = db(s_1_1)

        let s21db = db(s_2_1)

        let s12db = db(s_1_2)

        let s22db = db(s_2_2)

        let nfdb = real(NF)



        let delta = s_1_1*s_2_2-s_1_2*s_2_1

        let md = mag(delta)

        let a11 = mag(s_1_1)

        let a12 = mag(s_1_2)

        let a21 = mag(s_2_1)

        let a22 = mag(s_2_2)

        let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))

        let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

        let kval = (1-a11*a11-a22*a22+md*md)/(2*a12*a21)



        let zin = 50*(1+s_1_1)/(1-s_1_1)

        let zout = 50*(1+s_2_2)/(1-s_2_2)

        let zin_re = real(zin)

        let zin_im = imag(zin)

        let zout_re = real(zout)

        let zout_im = imag(zout)



        let s11w = maximum(s11db)

        let s21m = minimum(s21db)

        let s21x = maximum(s21db)

        let ripple = s21x-s21m

        let s22w = maximum(s22db)

        let nfw = maximum(nfdb)

        let mumin = minimum(mu)

        let mupmin = minimum(mup)

        let dmax = maximum(md)



        let s11c = s11db[25]

        let s21c = s21db[25]

        let s12c = s12db[25]

        let s22c = s22db[25]

        let nfc = nfdb[25]

        let zinrc = zin_re[25]

        let zinic = zin_im[25]

        let zoutrc = zout_re[25]

        let zoutic = zout_im[25]



        * ----- Formal score -----

        let penalty_gain = 0

        let penalty_nf = 0

        let penalty_ripple = 0

        let penalty_s11 = 0

        let penalty_s22 = 0

        let penalty_pdc = 0

        let penalty_mu = 0

        let penalty_mup = 0

        let penalty_delta = 0

        let passcount = 0



        if s21m < target_gain

          let penalty_gain = target_gain-s21m

        else

          let passcount = passcount+1

        end

        if nfw > target_nf

          let penalty_nf = nfw-target_nf

        else

          let passcount = passcount+1

        end

        if ripple > target_ripple

          let penalty_ripple = ripple-target_ripple

        else

          let passcount = passcount+1

        end

        if s11w > target_s11

          let penalty_s11 = s11w-target_s11

        else

          let passcount = passcount+1

        end

        if s22w > target_s22

          let penalty_s22 = s22w-target_s22

        else

          let passcount = passcount+1

        end

        if $op_pdc > target_pdc

          let penalty_pdc = $op_pdc-target_pdc

        else

          let passcount = passcount+1

        end

        if mumin < target_mu

          let penalty_mu = target_mu-mumin

        else

          let passcount = passcount+1

        end

        if mupmin < target_mu

          let penalty_mup = target_mu-mupmin

        else

          let passcount = passcount+1

        end

        if dmax >= target_delta

          let penalty_delta = dmax-target_delta+0.001

        else

          let passcount = passcount+1

        end



        let score = 320*penalty_gain+280*penalty_nf+180*penalty_ripple

        let score = score+35*penalty_s11+35*penalty_s22+2*penalty_pdc

        let score = score+300*penalty_mu+300*penalty_mup+600*penalty_delta

        let score = score+5*nfw-3*s21m+2*ripple+0.004*$op_pdc



        * Do not force very high gm; V20 showed capacitance can dominate.

        let penalty_gm3 = 0

        if $op_gm3 < 0.020

          let penalty_gm3 = 1000*(0.020-$op_gm3)

        end

        let score = score+5*penalty_gm3



        * Prefer a reasonably strong upper cascode without making it a hard RF constraint.

        let penalty_gm6 = 0

        if $op_gm6 < 0.015

          let penalty_gm6 = 1000*(0.015-$op_gm6)

        end

        let score = score+3*penalty_gm6



        * ----- Hard DC validity -----

        let dcvalid = 1

        if $op_pdc > target_pdc

          let dcvalid = 0

        end

        if $op_sat1 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat2 < min_satmargin_cg

          let dcvalid = 0

        end

        if $op_sat4 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat5 < min_satmargin_sink

          let dcvalid = 0

        end

        if $op_id5 < 0.0025

          let dcvalid = 0

        end

        if $op_id5 > 0.0060

          let dcvalid = 0

        end



        if $op_id3 < 0.008

          let dcvalid = 0

        end

        if $op_id3 > 0.030

          let dcvalid = 0

        end

        if $op_id6 < 0.008

          let dcvalid = 0

        end

        if $op_id6 > 0.030

          let dcvalid = 0

        end

        if $op_sat3 < min_satmargin_out_cs

          let dcvalid = 0

        end

        if $op_sat6 < min_satmargin_out_cas

          let dcvalid = 0

        end

        if $op_vs3 < 0

          let dcvalid = 0

        end

        if $op_vs3 > 0.50

          let dcvalid = 0

        end

        if $op_vx < 0.70

          let dcvalid = 0

        end

        if $op_vx > 2.30

          let dcvalid = 0

        end

        if $op_vout < 2.20

          let dcvalid = 0

        end

        if $op_vout > 4.50

          let dcvalid = 0

        end

        if $op_vout <= $op_vx

          let dcvalid = 0

        end

        if $op_vx <= $op_vs3

          let dcvalid = 0

        end



        let penalty_ratio = 0

        if $op_ratio25 < 3.0

          let penalty_ratio = 3.0-$op_ratio25

        end

        let penalty_gm5 = 0

        if $op_gm5 > 0.0065

          let penalty_gm5 = 1000*($op_gm5-0.0065)

        end

        let penalty_gds5 = 0

        if $op_gds5 > 0.0004

          let penalty_gds5 = 1000*($op_gds5-0.0004)

        end

        let score = score+30*penalty_ratio+10*penalty_gm5+20*penalty_gds5



        if dcvalid = 0

          let score = score+10000

        end



        let passall = 1

        if passcount < 9

          let passall = 0

        end

        if dcvalid = 0

          let passall = 0

        end



        echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo STAGE_D_POINT LIN $linv CSHIN $cshinv >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo OP PDC_mW $op_pdc VSCG $op_vscg VDCG $op_vdcg NET7 $op_v7 NET8 $op_v8 GBUF $op_vg3
+ SOURCE3 $op_vs3 INTERNAL_X $op_vx OUTPUT_DC $op_vout XM1_ID $op_id1 XM1_GM $op_gm1 XM1_GDS $op_gds1 XM1_VDS
+ $op_vds1 XM1_VDSAT $op_vdsat1 XM1_MARGIN $op_sat1 XM2_ID $op_id2 XM2_GM $op_gm2 XM2_GMB $op_gmb2 XM2_GMEFF
+ $op_gm2eff XM2_GDS $op_gds2 XM2_VDS $op_vds2 XM2_VDSAT $op_vdsat2 XM2_MARGIN $op_sat2 XM3_ID $op_id3 XM3_GM
+ $op_gm3 XM3_GMB $op_gmb3 XM3_GDS $op_gds3 XM3_GMID $op_gmid3 XM3_VGS $op_vgs3 XM3_VDS $op_vds3 XM3_VDSAT
+ $op_vdsat3 XM3_MARGIN $op_sat3 XM3_RO $op_ro3 XM4_ID $op_id4 XM4_GM $op_gm4 XM4_GDS $op_gds4 XM4_VDS $op_vds4
+ XM4_VDSAT $op_vdsat4 XM4_MARGIN $op_sat4 XM5_ID $op_id5 XM5_GM $op_gm5 XM5_GDS $op_gds5 XM5_GMID $op_gmid5
+ XM5_VDS $op_vds5 XM5_VDSAT $op_vdsat5 XM5_MARGIN $op_sat5 XM5_RO $op_ro5 XM6_ID $op_id6 XM6_GM $op_gm6
+ XM6_GMB $op_gmb6 XM6_GDS $op_gds6 XM6_GMID $op_gmid6 XM6_VGS $op_vgs6 XM6_VDS $op_vds6 XM6_VDSAT $op_vdsat6
+ XM6_MARGIN $op_sat6 XM6_RO $op_ro6 GMEFF2_OVER_GM5 $op_ratio25 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo RF SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL $&passall S11W_dB
+ $&s11w S21MIN_dB $&s21m S21MAX_dB $&s21x RIPPLE_dB $&ripple S22W_dB $&s22w NFW_dB $&nfw MU_MIN $&mumin
+ MUP_MIN $&mupmin DELTA_MAX $&dmax AT_2P4 S11_dB $&s11c S21_dB $&s21c S12_dB $&s12c S22_dB $&s22c NF_dB
+ $&nfc ZIN_RE $&zinrc ZIN_IM $&zinic ZOUT_RE $&zoutrc ZOUT_IM $&zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



        echo $linv $cshinv $&score $&dcvalid $&passcount $&passall $op_pdc $&s11w $&s21m $&s21x
+ $&ripple $&s22w $&nfw $&mumin $&mupmin $&dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt



        if score < $D_best_score

  set D_best_score = $&score

  set D_best_lin = $linv

  set D_best_cshin = $cshinv

  set D_best_passall = $&passall

end



        destroy $curplot



end

end

echo STAGE_D_BEST SCORE $D_best_score LIN $D_best_lin CSHIN $D_best_cshin PASSALL $D_best_passall >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* STAGE E — LOCAL CG/XM5 FRONT-END REFINEMENT

* 3 WCG x 3 RD1 x 3 VBCG x 3 VBICG x 3 W5 = 243 points.

* =============================================================================

set E_best_score = 1e99

set E_best_wcg = 130u

set E_best_rd1 = 660

set E_best_vbcg = 2.10

set E_best_vbicg = 1.60

set E_best_w5 = 35u

set E_best_passall = 0



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo STAGE_E_FRONT_END_REFINEMENT >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo WCG RD1 VBCG VBICG W5 SCORE DCVALID PASSCOUNT PASSALL PDC ID2 GM2 GMB2 ID5 GM5 GDS5 RATIO S11W
+ S21MIN S21MAX RIPPLE S22W NFW MU MUP DELTA >> lna_v22_cs_cascode_driver_corrected_summary.txt



foreach wcgv 120u 130u 140u

  foreach rd1v 620 660 700

    foreach vbcgv 2.0 2.1 2.2

      foreach vbicgv 1.5 1.6 1.7

        foreach w5v 30u 35u 40u

          alterparam W_CG = $wcgv

          alterparam RD1 = $rd1v

          alterparam VBIAS_CG = $vbcgv

          alterparam VBIAS_ICG = $vbicgv

          alterparam W_BIAS_CG = $w5v



          alterparam W_SF = $A_best_w3

          alterparam W_SF_CAS = $A_best_w6

          alterparam VBIAS_BUF = $A_best_vb3

          alterparam VBIAS_CAS_BUF = $A_best_vb6

          alterparam RD_OUT = $B_best_rd

          alterparam RS_OUT = $C_best_rs

          alterparam CSOUT_VAL = $C_best_cs

          alterparam COUT_VAL = $B_best_cout

          alterparam C_SH_OUT = $B_best_cshout

          alterparam L_IN = $D_best_lin

          alterparam C_SH_IN = $D_best_cshin



reset

        op



        * ----- DC operating point -----

        let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

        let vscgop = v(s)

        let vdcgop = v(d)

        let v7op = v(net7)

        let v8op = v(net8)

        let vg3op = v(g_buf)

        let vs3op = v(net3)

        let vxop = v(net9)

        let voutop = v(vbuf)



        let id1op = abs(@m.xm1.m0[id])

        let gm1op = @m.xm1.m0[gm]

        let gds1op = @m.xm1.m0[gds]

        let vds1op = v(net7)

        let vdsat1op = abs(@m.xm1.m0[vdsat])

        let sat1op = vds1op-vdsat1op



        let id2op = abs(@m.xm2.m0[id])

        let gm2op = @m.xm2.m0[gm]

        let gmb2op = @m.xm2.m0[gmbs]

        let gm2effop = gm2op+gmb2op

        let gds2op = @m.xm2.m0[gds]

        let vds2op = v(d)-v(s)

        let vdsat2op = abs(@m.xm2.m0[vdsat])

        let sat2op = vds2op-vdsat2op



        let id3op = abs(@m.xm3.m0[id])

        let gm3op = @m.xm3.m0[gm]

        let gmb3op = @m.xm3.m0[gmbs]

        let gds3op = @m.xm3.m0[gds]

        let gmid3op = gm3op/id3op

        let vgs3op = v(g_buf)-v(net3)

        let vds3op = v(net9)-v(net3)

        let vdsat3op = abs(@m.xm3.m0[vdsat])

        let sat3op = vds3op-vdsat3op

        let ro3op = 1/gds3op



        let id4op = abs(@m.xm4.m0[id])

        let gm4op = @m.xm4.m0[gm]

        let gds4op = @m.xm4.m0[gds]

        let vds4op = v(net8)-v(net7)

        let vdsat4op = abs(@m.xm4.m0[vdsat])

        let sat4op = vds4op-vdsat4op



        let id5op = abs(@m.xm5.m0[id])

        let gm5op = @m.xm5.m0[gm]

        let gds5op = @m.xm5.m0[gds]

        let gmid5op = gm5op/id5op

        let vds5op = v(s)

        let vdsat5op = abs(@m.xm5.m0[vdsat])

        let sat5op = vds5op-vdsat5op

        let ro5op = 1/gds5op



        let id6op = abs(@m.xm6.m0[id])

        let gm6op = @m.xm6.m0[gm]

        let gmb6op = @m.xm6.m0[gmbs]

        let gds6op = @m.xm6.m0[gds]

        let gmid6op = gm6op/id6op

        let vgs6op = v(vbias_cas_buf)-v(net9)

        let vds6op = v(vbuf)-v(net9)

        let vdsat6op = abs(@m.xm6.m0[vdsat])

        let sat6op = vds6op-vdsat6op

        let ro6op = 1/gds6op



        let ratio25op = gm2effop/gm5op



        set op_pdc = $&pdcop

        set op_vscg = $&vscgop

        set op_vdcg = $&vdcgop

        set op_v7 = $&v7op

        set op_v8 = $&v8op

        set op_vg3 = $&vg3op

        set op_vs3 = $&vs3op

        set op_vx = $&vxop

        set op_vout = $&voutop



        set op_id1 = $&id1op

        set op_gm1 = $&gm1op

        set op_gds1 = $&gds1op

        set op_vds1 = $&vds1op

        set op_vdsat1 = $&vdsat1op

        set op_sat1 = $&sat1op



        set op_id2 = $&id2op

        set op_gm2 = $&gm2op

        set op_gmb2 = $&gmb2op

        set op_gm2eff = $&gm2effop

        set op_gds2 = $&gds2op

        set op_vds2 = $&vds2op

        set op_vdsat2 = $&vdsat2op

        set op_sat2 = $&sat2op



        set op_id3 = $&id3op

        set op_gm3 = $&gm3op

        set op_gmb3 = $&gmb3op

        set op_gds3 = $&gds3op

        set op_gmid3 = $&gmid3op

        set op_vgs3 = $&vgs3op

        set op_vds3 = $&vds3op

        set op_vdsat3 = $&vdsat3op

        set op_sat3 = $&sat3op

        set op_ro3 = $&ro3op



        set op_id4 = $&id4op

        set op_gm4 = $&gm4op

        set op_gds4 = $&gds4op

        set op_vds4 = $&vds4op

        set op_vdsat4 = $&vdsat4op

        set op_sat4 = $&sat4op



        set op_id5 = $&id5op

        set op_gm5 = $&gm5op

        set op_gds5 = $&gds5op

        set op_gmid5 = $&gmid5op

        set op_vds5 = $&vds5op

        set op_vdsat5 = $&vdsat5op

        set op_sat5 = $&sat5op

        set op_ro5 = $&ro5op



        set op_id6 = $&id6op

        set op_gm6 = $&gm6op

        set op_gmb6 = $&gmb6op

        set op_gds6 = $&gds6op

        set op_gmid6 = $&gmid6op

        set op_vgs6 = $&vgs6op

        set op_vds6 = $&vds6op

        set op_vdsat6 = $&vdsat6op

        set op_sat6 = $&sat6op

        set op_ro6 = $&ro6op

        set op_ratio25 = $&ratio25op



        destroy $curplot



        * ----- RF/noise/stability over target band -----

        sp lin 51 2.30G 2.50G 1

        let s11db = db(s_1_1)

        let s21db = db(s_2_1)

        let s12db = db(s_1_2)

        let s22db = db(s_2_2)

        let nfdb = real(NF)



        let delta = s_1_1*s_2_2-s_1_2*s_2_1

        let md = mag(delta)

        let a11 = mag(s_1_1)

        let a12 = mag(s_1_2)

        let a21 = mag(s_2_1)

        let a22 = mag(s_2_2)

        let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))

        let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

        let kval = (1-a11*a11-a22*a22+md*md)/(2*a12*a21)



        let zin = 50*(1+s_1_1)/(1-s_1_1)

        let zout = 50*(1+s_2_2)/(1-s_2_2)

        let zin_re = real(zin)

        let zin_im = imag(zin)

        let zout_re = real(zout)

        let zout_im = imag(zout)



        let s11w = maximum(s11db)

        let s21m = minimum(s21db)

        let s21x = maximum(s21db)

        let ripple = s21x-s21m

        let s22w = maximum(s22db)

        let nfw = maximum(nfdb)

        let mumin = minimum(mu)

        let mupmin = minimum(mup)

        let dmax = maximum(md)



        let s11c = s11db[25]

        let s21c = s21db[25]

        let s12c = s12db[25]

        let s22c = s22db[25]

        let nfc = nfdb[25]

        let zinrc = zin_re[25]

        let zinic = zin_im[25]

        let zoutrc = zout_re[25]

        let zoutic = zout_im[25]



        * ----- Formal score -----

        let penalty_gain = 0

        let penalty_nf = 0

        let penalty_ripple = 0

        let penalty_s11 = 0

        let penalty_s22 = 0

        let penalty_pdc = 0

        let penalty_mu = 0

        let penalty_mup = 0

        let penalty_delta = 0

        let passcount = 0



        if s21m < target_gain

          let penalty_gain = target_gain-s21m

        else

          let passcount = passcount+1

        end

        if nfw > target_nf

          let penalty_nf = nfw-target_nf

        else

          let passcount = passcount+1

        end

        if ripple > target_ripple

          let penalty_ripple = ripple-target_ripple

        else

          let passcount = passcount+1

        end

        if s11w > target_s11

          let penalty_s11 = s11w-target_s11

        else

          let passcount = passcount+1

        end

        if s22w > target_s22

          let penalty_s22 = s22w-target_s22

        else

          let passcount = passcount+1

        end

        if $op_pdc > target_pdc

          let penalty_pdc = $op_pdc-target_pdc

        else

          let passcount = passcount+1

        end

        if mumin < target_mu

          let penalty_mu = target_mu-mumin

        else

          let passcount = passcount+1

        end

        if mupmin < target_mu

          let penalty_mup = target_mu-mupmin

        else

          let passcount = passcount+1

        end

        if dmax >= target_delta

          let penalty_delta = dmax-target_delta+0.001

        else

          let passcount = passcount+1

        end



        let score = 320*penalty_gain+280*penalty_nf+180*penalty_ripple

        let score = score+35*penalty_s11+35*penalty_s22+2*penalty_pdc

        let score = score+300*penalty_mu+300*penalty_mup+600*penalty_delta

        let score = score+5*nfw-3*s21m+2*ripple+0.004*$op_pdc



        * Do not force very high gm; V20 showed capacitance can dominate.

        let penalty_gm3 = 0

        if $op_gm3 < 0.020

          let penalty_gm3 = 1000*(0.020-$op_gm3)

        end

        let score = score+5*penalty_gm3



        * Prefer a reasonably strong upper cascode without making it a hard RF constraint.

        let penalty_gm6 = 0

        if $op_gm6 < 0.015

          let penalty_gm6 = 1000*(0.015-$op_gm6)

        end

        let score = score+3*penalty_gm6



        * ----- Hard DC validity -----

        let dcvalid = 1

        if $op_pdc > target_pdc

          let dcvalid = 0

        end

        if $op_sat1 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat2 < min_satmargin_cg

          let dcvalid = 0

        end

        if $op_sat4 < min_satmargin_core

          let dcvalid = 0

        end

        if $op_sat5 < min_satmargin_sink

          let dcvalid = 0

        end

        if $op_id5 < 0.0025

          let dcvalid = 0

        end

        if $op_id5 > 0.0060

          let dcvalid = 0

        end



        if $op_id3 < 0.008

          let dcvalid = 0

        end

        if $op_id3 > 0.030

          let dcvalid = 0

        end

        if $op_id6 < 0.008

          let dcvalid = 0

        end

        if $op_id6 > 0.030

          let dcvalid = 0

        end

        if $op_sat3 < min_satmargin_out_cs

          let dcvalid = 0

        end

        if $op_sat6 < min_satmargin_out_cas

          let dcvalid = 0

        end

        if $op_vs3 < 0

          let dcvalid = 0

        end

        if $op_vs3 > 0.50

          let dcvalid = 0

        end

        if $op_vx < 0.70

          let dcvalid = 0

        end

        if $op_vx > 2.30

          let dcvalid = 0

        end

        if $op_vout < 2.20

          let dcvalid = 0

        end

        if $op_vout > 4.50

          let dcvalid = 0

        end

        if $op_vout <= $op_vx

          let dcvalid = 0

        end

        if $op_vx <= $op_vs3

          let dcvalid = 0

        end



        let penalty_ratio = 0

        if $op_ratio25 < 3.0

          let penalty_ratio = 3.0-$op_ratio25

        end

        let penalty_gm5 = 0

        if $op_gm5 > 0.0065

          let penalty_gm5 = 1000*($op_gm5-0.0065)

        end

        let penalty_gds5 = 0

        if $op_gds5 > 0.0004

          let penalty_gds5 = 1000*($op_gds5-0.0004)

        end

        let score = score+30*penalty_ratio+10*penalty_gm5+20*penalty_gds5



        if dcvalid = 0

          let score = score+10000

        end



        let passall = 1

        if passcount < 9

          let passall = 0

        end

        if dcvalid = 0

          let passall = 0

        end



        echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo STAGE_E_POINT WCG $wcgv RD1 $rd1v VBCG $vbcgv VBICG $vbicgv W5 $w5v >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo OP PDC_mW $op_pdc VSCG $op_vscg VDCG $op_vdcg NET7 $op_v7 NET8 $op_v8 GBUF $op_vg3
+ SOURCE3 $op_vs3 INTERNAL_X $op_vx OUTPUT_DC $op_vout XM1_ID $op_id1 XM1_GM $op_gm1 XM1_GDS $op_gds1 XM1_VDS
+ $op_vds1 XM1_VDSAT $op_vdsat1 XM1_MARGIN $op_sat1 XM2_ID $op_id2 XM2_GM $op_gm2 XM2_GMB $op_gmb2 XM2_GMEFF
+ $op_gm2eff XM2_GDS $op_gds2 XM2_VDS $op_vds2 XM2_VDSAT $op_vdsat2 XM2_MARGIN $op_sat2 XM3_ID $op_id3 XM3_GM
+ $op_gm3 XM3_GMB $op_gmb3 XM3_GDS $op_gds3 XM3_GMID $op_gmid3 XM3_VGS $op_vgs3 XM3_VDS $op_vds3 XM3_VDSAT
+ $op_vdsat3 XM3_MARGIN $op_sat3 XM3_RO $op_ro3 XM4_ID $op_id4 XM4_GM $op_gm4 XM4_GDS $op_gds4 XM4_VDS $op_vds4
+ XM4_VDSAT $op_vdsat4 XM4_MARGIN $op_sat4 XM5_ID $op_id5 XM5_GM $op_gm5 XM5_GDS $op_gds5 XM5_GMID $op_gmid5
+ XM5_VDS $op_vds5 XM5_VDSAT $op_vdsat5 XM5_MARGIN $op_sat5 XM5_RO $op_ro5 XM6_ID $op_id6 XM6_GM $op_gm6
+ XM6_GMB $op_gmb6 XM6_GDS $op_gds6 XM6_GMID $op_gmid6 XM6_VGS $op_vgs6 XM6_VDS $op_vds6 XM6_VDSAT $op_vdsat6
+ XM6_MARGIN $op_sat6 XM6_RO $op_ro6 GMEFF2_OVER_GM5 $op_ratio25 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt

        echo RF SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL $&passall S11W_dB
+ $&s11w S21MIN_dB $&s21m S21MAX_dB $&s21x RIPPLE_dB $&ripple S22W_dB $&s22w NFW_dB $&nfw MU_MIN $&mumin
+ MUP_MIN $&mupmin DELTA_MAX $&dmax AT_2P4 S11_dB $&s11c S21_dB $&s21c S12_dB $&s12c S22_dB $&s22c NF_dB
+ $&nfc ZIN_RE $&zinrc ZIN_IM $&zinic ZOUT_RE $&zoutrc ZOUT_IM $&zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



        echo $wcgv $rd1v $vbcgv $vbicgv $w5v $&score $&dcvalid $&passcount $&passall $op_pdc $op_id2
+ $op_gm2 $op_gmb2 $op_id5 $op_gm5 $op_gds5 $op_ratio25 $&s11w $&s21m $&s21x $&ripple $&s22w $&nfw $&mumin
+ $&mupmin $&dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt



        if score < $E_best_score

  set E_best_score = $&score

  set E_best_wcg = $wcgv

  set E_best_rd1 = $rd1v

  set E_best_vbcg = $vbcgv

  set E_best_vbicg = $vbicgv

  set E_best_w5 = $w5v

  set E_best_passall = $&passall

end



        destroy $curplot



end

      end

    end

  end

end

echo STAGE_E_BEST SCORE $E_best_score WCG $E_best_wcg RD1 $E_best_rd1 VBCG $E_best_vbcg VBICG
+ $E_best_vbicg W5 $E_best_w5 PASSALL $E_best_passall >> lna_v22_cs_cascode_driver_corrected_summary.txt



* =============================================================================

* APPLY FINAL SELECTED PARAMETERS

* =============================================================================

alterparam W_CG = $E_best_wcg

alterparam RD1 = $E_best_rd1

alterparam VBIAS_CG = $E_best_vbcg

alterparam VBIAS_ICG = $E_best_vbicg

alterparam W_BIAS_CG = $E_best_w5



alterparam W_SF = $A_best_w3

alterparam W_SF_CAS = $A_best_w6

alterparam VBIAS_BUF = $A_best_vb3

alterparam VBIAS_CAS_BUF = $A_best_vb6

alterparam RD_OUT = $B_best_rd

alterparam RS_OUT = $C_best_rs

alterparam CSOUT_VAL = $C_best_cs

alterparam COUT_VAL = $B_best_cout

alterparam C_SH_OUT = $B_best_cshout

alterparam L_IN = $D_best_lin

alterparam C_SH_IN = $D_best_cshin



reset

op



let final_pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))

let final_vs3op = v(net3)

let final_vxop = v(net9)

let final_voutop = v(vbuf)



let final_id1op = abs(@m.xm1.m0[id])

let final_gm1op = @m.xm1.m0[gm]

let final_vds1op = v(net7)

let final_vdsat1op = abs(@m.xm1.m0[vdsat])

let final_sat1op = final_vds1op-final_vdsat1op



let final_id2op = abs(@m.xm2.m0[id])

let final_gm2op = @m.xm2.m0[gm]

let final_gmb2op = @m.xm2.m0[gmbs]

let final_vds2op = v(d)-v(s)

let final_vdsat2op = abs(@m.xm2.m0[vdsat])

let final_sat2op = final_vds2op-final_vdsat2op



let final_id3op = abs(@m.xm3.m0[id])

let final_gm3op = @m.xm3.m0[gm]

let final_gds3op = @m.xm3.m0[gds]

let final_vgs3op = v(g_buf)-v(net3)

let final_vds3op = v(net9)-v(net3)

let final_vdsat3op = abs(@m.xm3.m0[vdsat])

let final_sat3op = final_vds3op-final_vdsat3op



let final_id4op = abs(@m.xm4.m0[id])

let final_gm4op = @m.xm4.m0[gm]

let final_vds4op = v(net8)-v(net7)

let final_vdsat4op = abs(@m.xm4.m0[vdsat])

let final_sat4op = final_vds4op-final_vdsat4op



let final_id5op = abs(@m.xm5.m0[id])

let final_gm5op = @m.xm5.m0[gm]

let final_gds5op = @m.xm5.m0[gds]

let final_vds5op = v(s)

let final_vdsat5op = abs(@m.xm5.m0[vdsat])

let final_sat5op = final_vds5op-final_vdsat5op



let final_id6op = abs(@m.xm6.m0[id])

let final_gm6op = @m.xm6.m0[gm]

let final_gds6op = @m.xm6.m0[gds]

let final_vgs6op = v(vbias_cas_buf)-v(net9)

let final_vds6op = v(vbuf)-v(net9)

let final_vdsat6op = abs(@m.xm6.m0[vdsat])

let final_sat6op = final_vds6op-final_vdsat6op



set final_pdc = $&final_pdcop

set final_vs3 = $&final_vs3op

set final_vx = $&final_vxop

set final_vout = $&final_voutop

set final_id1 = $&final_id1op

set final_gm1 = $&final_gm1op

set final_vds1 = $&final_vds1op

set final_vdsat1 = $&final_vdsat1op

set final_sat1 = $&final_sat1op

set final_id2 = $&final_id2op

set final_gm2 = $&final_gm2op

set final_gmb2 = $&final_gmb2op

set final_vds2 = $&final_vds2op

set final_vdsat2 = $&final_vdsat2op

set final_sat2 = $&final_sat2op

set final_id3 = $&final_id3op

set final_gm3 = $&final_gm3op

set final_gds3 = $&final_gds3op

set final_vgs3 = $&final_vgs3op

set final_vds3 = $&final_vds3op

set final_vdsat3 = $&final_vdsat3op

set final_sat3 = $&final_sat3op

set final_id4 = $&final_id4op

set final_gm4 = $&final_gm4op

set final_vds4 = $&final_vds4op

set final_vdsat4 = $&final_vdsat4op

set final_sat4 = $&final_sat4op

set final_id5 = $&final_id5op

set final_gm5 = $&final_gm5op

set final_gds5 = $&final_gds5op

set final_vds5 = $&final_vds5op

set final_vdsat5 = $&final_vdsat5op

set final_sat5 = $&final_sat5op

set final_id6 = $&final_id6op

set final_gm6 = $&final_gm6op

set final_gds6 = $&final_gds6op

set final_vgs6 = $&final_vgs6op

set final_vds6 = $&final_vds6op

set final_vdsat6 = $&final_vdsat6op

set final_sat6 = $&final_sat6op



echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_SELECTED_PARAMETERS >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo FRONT WCG $E_best_wcg RD1 $E_best_rd1 VBCG $E_best_vbcg VBICG $E_best_vbicg W5 $E_best_w5 L5
+ 0.50u >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo OUTPUT W3 $A_best_w3 M3 2 L3 0.60u W6 $A_best_w6 M6 2 L6 0.60u VB3 $A_best_vb3 VBCAS
+ $A_best_vb6 RD $B_best_rd RS $C_best_rs CS $C_best_cs COUT $B_best_cout CSHOUT $B_best_cshout >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo INPUT LIN $D_best_lin CSHIN $D_best_cshin LOUT 0 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_DC PDC_mW $final_pdc VS3 $final_vs3 VX_INTERNAL $final_vx VOUT_DC $final_vout XM1_ID
+ $final_id1 XM1_GM $final_gm1 XM1_VDS $final_vds1 XM1_VDSAT $final_vdsat1 XM1_MARGIN $final_sat1 XM2_ID
+ $final_id2 XM2_GM $final_gm2 XM2_GMB $final_gmb2 XM2_VDS $final_vds2 XM2_VDSAT $final_vdsat2 XM2_MARGIN
+ $final_sat2 XM3_ID $final_id3 XM3_GM $final_gm3 XM3_GDS $final_gds3 XM3_VGS $final_vgs3 XM3_VDS $final_vds3
+ XM3_VDSAT $final_vdsat3 XM3_MARGIN $final_sat3 XM4_ID $final_id4 XM4_GM $final_gm4 XM4_VDS $final_vds4
+ XM4_VDSAT $final_vdsat4 XM4_MARGIN $final_sat4 XM5_ID $final_id5 XM5_GM $final_gm5 XM5_GDS $final_gds5
+ XM5_VDS $final_vds5 XM5_VDSAT $final_vdsat5 XM5_MARGIN $final_sat5 XM6_ID $final_id6 XM6_GM $final_gm6
+ XM6_GDS $final_gds6 XM6_VGS $final_vgs6 XM6_VDS $final_vds6 XM6_VDSAT $final_vdsat6 XM6_MARGIN $final_sat6
+ >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_DC PDC_mW $final_pdc VS3 $final_vs3 VX_INTERNAL $final_vx VOUT_DC $final_vout XM1_ID
+ $final_id1 XM1_GM $final_gm1 XM1_MARGIN $final_sat1 XM2_ID $final_id2 XM2_GM $final_gm2 XM2_GMB $final_gmb2
+ XM2_MARGIN $final_sat2 XM3_ID $final_id3 XM3_GM $final_gm3 XM3_GDS $final_gds3 XM3_VGS $final_vgs3 XM3_VDS
+ $final_vds3 XM3_MARGIN $final_sat3 XM4_ID $final_id4 XM4_GM $final_gm4 XM4_MARGIN $final_sat4 XM5_ID $final_id5
+ XM5_GM $final_gm5 XM5_GDS $final_gds5 XM5_MARGIN $final_sat5 XM6_ID $final_id6 XM6_GM $final_gm6 XM6_GDS
+ $final_gds6 XM6_VGS $final_vgs6 XM6_VDS $final_vds6 XM6_MARGIN $final_sat6 >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



destroy $curplot



* =============================================================================

* FINAL 201-POINT TARGET-BAND VERIFICATION

* =============================================================================

sp lin 201 2.30G 2.50G 1

let fs11db = db(s_1_1)

let fs21db = db(s_2_1)

let fs12db = db(s_1_2)

let fs22db = db(s_2_2)

let fnfdb = real(NF)



let fdelta = s_1_1*s_2_2-s_1_2*s_2_1

let fmd = mag(fdelta)

let fa11 = mag(s_1_1)

let fa12 = mag(s_1_2)

let fa21 = mag(s_2_1)

let fa22 = mag(s_2_2)

let fmu = (1-fa11*fa11)/(mag(s_2_2-fdelta*conj(s_1_1))+mag(s_1_2*s_2_1))

let fmup = (1-fa22*fa22)/(mag(s_1_1-fdelta*conj(s_2_2))+mag(s_1_2*s_2_1))

let fk = (1-fa11*fa11-fa22*fa22+fmd*fmd)/(2*fa12*fa21)



let fzin = 50*(1+s_1_1)/(1-s_1_1)

let fzout = 50*(1+s_2_2)/(1-s_2_2)

let fzinre = real(fzin)

let fzinim = imag(fzin)

let fzoutre = real(fzout)

let fzoutim = imag(fzout)



let fs11w = maximum(fs11db)

let fs21m = minimum(fs21db)

let fs21x = maximum(fs21db)

let fripple = fs21x-fs21m

let fs22w = maximum(fs22db)

let fnfw = maximum(fnfdb)

let fmumin = minimum(fmu)

let fmupmin = minimum(fmup)

let fdmax = maximum(fmd)



let fs11c = fs11db[100]

let fs21c = fs21db[100]

let fs12c = fs12db[100]

let fs22c = fs22db[100]

let fnfc = fnfdb[100]

let fzinrc = fzinre[100]

let fzinic = fzinim[100]

let fzoutrc = fzoutre[100]

let fzoutic = fzoutim[100]



set final_s11w = $&fs11w

set final_s21m = $&fs21m

set final_s21x = $&fs21x

set final_ripple = $&fripple

set final_s22w = $&fs22w

set final_nfw = $&fnfw

set final_mumin = $&fmumin

set final_mupmin = $&fmupmin

set final_dmax = $&fdmax

set final_s11c = $&fs11c

set final_s21c = $&fs21c

set final_s12c = $&fs12c

set final_s22c = $&fs22c

set final_nfc = $&fnfc

set final_zinrc = $&fzinrc

set final_zinic = $&fzinic

set final_zoutrc = $&fzoutrc

set final_zoutic = $&fzoutic



echo FINAL_TARGET_BAND S11W_dB $final_s11w S21MIN_dB $final_s21m S21MAX_dB $final_s21x RIPPLE_dB
+ $final_ripple S22W_dB $final_s22w NFW_dB $final_nfw MU_MIN $final_mumin MUP_MIN $final_mupmin DELTA_MAX
+ $final_dmax >> lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_AT_2P4 S11_dB $final_s11c S21_dB $final_s21c S12_dB $final_s12c S22_dB $final_s22c NF_dB
+ $final_nfc ZIN_RE $final_zinrc ZIN_IM $final_zinic ZOUT_RE $final_zoutrc ZOUT_IM $final_zoutic >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_TARGET_BAND S11W_dB $final_s11w S21MIN_dB $final_s21m S21MAX_dB $final_s21x RIPPLE_dB
+ $final_ripple S22W_dB $final_s22w NFW_dB $final_nfw MU_MIN $final_mumin MUP_MIN $final_mupmin DELTA_MAX
+ $final_dmax >> lna_v22_cs_cascode_driver_corrected_detailed.txt

echo FINAL_AT_2P4 S11_dB $final_s11c S21_dB $final_s21c S12_dB $final_s12c S22_dB $final_s22c NF_dB
+ $final_nfc ZIN_RE $final_zinrc ZIN_IM $final_zinic ZOUT_RE $final_zoutrc ZOUT_IM $final_zoutic >>
+ lna_v22_cs_cascode_driver_corrected_detailed.txt



wrdata lna_v22_cs_cascode_driver_corrected_detailed.txt frequency s_1_1 s_2_1 s_1_2 s_2_2 fs11db
+ fs21db fs12db fs22db fnfdb fk fmu fmup fmd fzinre fzinim fzoutre fzoutim

destroy $curplot



* =============================================================================

* WIDEBAND STABILITY: 10 MHz TO 30 GHz

* =============================================================================

sp dec 101 10Meg 30G 1

let wbdelta = s_1_1*s_2_2-s_1_2*s_2_1

let wbmd = mag(wbdelta)

let wba11 = mag(s_1_1)

let wba12 = mag(s_1_2)

let wba21 = mag(s_2_1)

let wba22 = mag(s_2_2)

let wbmu = (1-wba11*wba11)/(mag(s_2_2-wbdelta*conj(s_1_1))+mag(s_1_2*s_2_1))

let wbmup = (1-wba22*wba22)/(mag(s_1_1-wbdelta*conj(s_2_2))+mag(s_1_2*s_2_1))

let wbk = (1-wba11*wba11-wba22*wba22+wbmd*wbmd)/(2*wba12*wba21)

let wbkmin = minimum(wbk)

let wbmumin = minimum(wbmu)

let wbmupmin = minimum(wbmup)

let wbdmax = maximum(wbmd)



set final_wbkmin = $&wbkmin

set final_wbmumin = $&wbmumin

set final_wbmupmin = $&wbmupmin

set final_wbdmax = $&wbdmax



echo WIDEBAND_STABILITY_10MHZ_TO_30GHZ KMIN $final_wbkmin MU_MIN $final_wbmumin MUP_MIN
+ $final_wbmupmin DELTA_MAX $final_wbdmax >> lna_v22_cs_cascode_driver_corrected_summary.txt

wrdata lna_v22_cs_cascode_driver_corrected_detailed.txt frequency wbk wbmu wbmup wbmd



* =============================================================================

* PASS / FAIL REPORT

* =============================================================================

echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_PASS_FAIL >> lna_v22_cs_cascode_driver_corrected_summary.txt



if $final_s11w <= target_s11

  echo S11 PASS worst_dB $final_s11w limit_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo S11 FAIL worst_dB $final_s11w limit_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_s22w <= target_s22

  echo S22 PASS worst_dB $final_s22w limit_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo S22 FAIL worst_dB $final_s22w limit_dB -10 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_s21m >= target_gain

  echo GAIN PASS minimum_dB $final_s21m limit_dB 12 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo GAIN FAIL minimum_dB $final_s21m limit_dB 12 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_nfw <= target_nf

  echo NF PASS worst_dB $final_nfw limit_dB 4 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo NF FAIL worst_dB $final_nfw limit_dB 4 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_ripple <= target_ripple

  echo RIPPLE PASS value_dB $final_ripple limit_dB 1.20 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo RIPPLE FAIL value_dB $final_ripple limit_dB 1.20 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_pdc <= target_pdc

  echo PDC PASS value_mW $final_pdc limit_mW 220 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo PDC FAIL value_mW $final_pdc limit_mW 220 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_mumin >= target_mu

  echo MU PASS value $final_mumin limit 1.05 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo MU FAIL value $final_mumin limit 1.05 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_mupmin >= target_mu

  echo MUP PASS value $final_mupmin limit 1.05 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo MUP FAIL value $final_mupmin limit 1.05 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_dmax < target_delta

  echo DELTA PASS value $final_dmax limit 1.0 >> lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo DELTA FAIL value $final_dmax limit 1.0 >> lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_sat3 >= min_satmargin_out_cs

  echo XM3_SATURATION PASS MARGIN_V $final_sat3 LIMIT_V 0.30 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo XM3_SATURATION FAIL MARGIN_V $final_sat3 LIMIT_V 0.30 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_sat6 >= min_satmargin_out_cas

  echo XM6_CASCODE_SATURATION PASS MARGIN_V $final_sat6 LIMIT_V 0.40 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

else

  echo XM6_CASCODE_SATURATION FAIL MARGIN_V $final_sat6 LIMIT_V 0.40 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_vx >= 0.70

  if $final_vx <= 2.30

    echo INTERNAL_NODE PASS VX_V $final_vx RANGE_V 0.70 2.30 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

  else

    echo INTERNAL_NODE FAIL VX_V $final_vx RANGE_V 0.70 2.30 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

  end

else

  echo INTERNAL_NODE FAIL VX_V $final_vx RANGE_V 0.70 2.30 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



if $final_vout >= 2.20

  if $final_vout <= 4.50

    echo OUTPUT_DC PASS VOUT_V $final_vout RANGE_V 2.20 4.50 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

  else

    echo OUTPUT_DC FAIL VOUT_V $final_vout RANGE_V 2.20 4.50 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

  end

else

  echo OUTPUT_DC FAIL VOUT_V $final_vout RANGE_V 2.20 4.50 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

end



echo INDUCTANCE PASS L_IN $D_best_lin L_OUT 0 LIMIT_TOTAL 2nH >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo REQUIRED_SCHEMATIC_CHECK COUT_MUST_CONNECT_net9_to_net4 >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo DETAILED_FILE lna_v22_cs_cascode_driver_corrected_detailed.txt >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo SUMMARY_FILE lna_v22_cs_cascode_driver_corrected_summary.txt >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo FINAL_SELECTED_PARAMETERS_LEFT_ACTIVE_IN_SIMULATION >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt

echo ============================================================ >>
+ lna_v22_cs_cascode_driver_corrected_summary.txt



quit

.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
