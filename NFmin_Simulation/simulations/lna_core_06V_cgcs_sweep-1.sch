** sch_path: NFmin_Simulation/simulations/lna_core_06V_cgcs_sweep-1.sch
**.subckt lna_core_06V_cgcs_sweep-1
VBCG vbias_cg GND {VBIAS_CG}
VDD vdcbias GND {VDS}
C12 d g_cs {C12_VAL} m=1
CIN net7 s {CIN_VAL} m=1
V1 rf_in_ext GND DC 0 AC 1 0 portnum 1 z0 50
V2 rf_out_ext GND DC 0 AC 1 0 portnum 2 z0 50
XM2 d g_cg s GND nfet_06v0 L={L_CG} W={W_CG} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CG}
RBCG g_cg vbias_cg {RBIAS_CG} m=1
CBCG g_cg GND {CBYP_CG} m=1
x1 rf_in_pad vddio GND vddio GND gf180mcu_fd_io__asig_5p0
LBW_IN rf_in_pad net1 {L_BW} m=1
RBW_IN net1 rf_in_ext {R_BW} m=1
VDDIO vddio GND {VDDIO_SUP}
x2 rf_out_pad vddio GND vddio GND gf180mcu_fd_io__asig_5p0
LBW_IN1 rf_out_pad net2 {L_BW} m=1
RBW_IN1 net2 rf_out_ext {R_BW} m=1
VBCS vbias_cs GND {VBIAS_CS}
RD1_LOAD vdcbias d {RD1} m=1
RBCS g_cs vbias_cs {RBIAS_CS} m=1
RD2_LOAD vdcbias net9 {RD2} m=1
XM3 vdcbias net10 vbuf vbuf nfet_06v0 L={L_SF} W={W_SF} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_SF}
COUT vbuf net4 {COUT_VAL} m=1
LOUT net5 net4 {L_OUT} m=1
RLOUT rf_out_pad net5 {R_L_OUT} m=1
CSHOUT rf_out_pad GND {C_SH_OUT} m=1
CSHIN rf_in_pad GND {C_SH_IN} m=1
LIN net6 rf_in_pad {L_IN} m=1
RLIN net7 net6 {R_L_IN} m=1
XM4 net9 vbias_cas net8 GND nfet_06v0 L={L_CAS} W={W_CAS} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CAS}
VBCS1 vbias_cas GND {VBIAS_CAS}
VBCS2 vbias_buf GND {VBIAS_BUF}
VBCS3 vbias_icg GND {VBIAS_ICG}
XM5 s vbias_icg GND GND nfet_03v3 L={L_BIAS_CG} W={W_BIAS_CG} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u'
+ as='int((nf+2)/2) * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)'
+ nrd='0.18u / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m={M_BIAS_CG}
XM6 vbuf vbias_buf GND GND nfet_03v3 L={L_BIAS_SF} W={W_BIAS_SF} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u'
+ as='int((nf+2)/2) * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)'
+ nrd='0.18u / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m={M_BIAS_SF}
RS_EQ net3 GND {RS_EQ} m=1
CS_EQ net3 GND {CSEQ_VAL} m=1
XM1 net8 g_cs net3 GND nfet_03v3 L={L_CS} W={W_CS} nf=10 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m={M_CS}
RG_SF net10 net9 {RG_SF_VAL} m=1
**** begin user architecture code

.include /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice

.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_typical

*.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/spice/gf180mcu_fd_io.spice
.include /media/sf_LNA_chipathon/The-Silent-Owl-GF180MCU-WB-LNA/analog_pad_sp_paramerters/xschem/gf180mcu_fd_io__asig_5p0.spice




* Supply / package
.param VDS=5.0
.param VDDIO_SUP=5.0
.param L_BW=2n
.param R_BW=0.2

* Input network; legal intentional total = 2 nH
.param L_IN=1.80n
.param R_L_IN=1.5
.param CIN_VAL=100p
.param C_SH_IN=1f

* XM2 common-gate input
.param VBIAS_CG=2.05
.param W_CG=160u
.param M_CG=2
.param L_CG=0.60u
.param RD1=680
.param RBIAS_CG=50k
.param CBYP_CG=20p

* Mixed-voltage XM1/XM4 stage
.param C12_VAL=47p
.param VBIAS_CS=0.95
.param W_CS=40u
.param M_CS=2
.param L_CS=0.28u
.param RBIAS_CS=50k
.param VBIAS_CAS=3.30
.param W_CAS=70u
.param M_CAS=1
.param L_CAS=0.60u
.param RD2=470

* XM1 source equalizer
.param RS_EQ=8
.param CSEQ_VAL=8.2p

* Body-tied source follower and gate stopper
.param W_SF=125u
.param M_SF=2
.param L_SF=0.60u
.param RG_SF_VAL=0.25

* Output network
.param COUT_VAL=47p
.param L_OUT=0.20n
.param R_L_OUT=1.5
.param C_SH_OUT=1f

* XM5 common-gate current sink
.param VBIAS_ICG=1.65
.param L_BIAS_CG=0.50u
.param W_BIAS_CG=25u
.param M_BIAS_CG=1

* XM6 follower current sink
.param VBIAS_BUF=2.20
.param L_BIAS_SF=0.50u
.param W_BIAS_SF=50u
.param M_BIAS_SF=3

* Series-RC shunt snubber from net9 to ground
.param C_STAB_VAL=1f
.param R_STAB_VAL=50
C_STAB net9 n_stab {C_STAB_VAL}
R_STAB n_stab GND {R_STAB_VAL}

.control
set noaskquit
set wr_singlescale
set wr_vecnames
set numdgt=10
set appendwrite

* Formal specifications
let target_s11 = -10
let target_s22 = -10
let target_gain = 15.0
let target_nf = 3.50
let target_ripple = 1.20
let target_pdc = 300
let target_mu = 1.05
let target_delta = 1.0

* Desired nominal margins
let margin_s11 = -12.0
let margin_s22 = -14.0
let margin_gain = 15.50
let margin_nf = 3.35
let margin_ripple = 1.10
let margin_tilt = 1.00
let margin_pdc = 240
let margin_mu_band = 1.20
let margin_mu_wide = 1.00
let margin_sat5 = 0.20
let margin_ratio25 = 4.00

* Hard validity
let min_satmargin_sink = 0.20
let min_satmargin_xm1 = 0.25
let min_satmargin_core = 0.40
let min_satmargin_cg = 0.50
let max_03v3_terminal = 3.00
let ltotal_limit = 2.0001e-9

echo ============================================================ >
+ lna_v26_gain_nf_priority_summary.txt
echo LNA_V26_HIGH_GAIN_LOW_NF_GLOBAL_OPTIMIZER >> lna_v26_gain_nf_priority_summary.txt
echo FORMAL S11_-10 S22_-10 GAIN_15 NF_3P50 RIPPLE_1P2 PDC_300 MU_1P05 >>
+ lna_v26_gain_nf_priority_summary.txt
echo MARGIN S11_-12 S22_-14 GAIN_15P50 NF_3P35 RIPPLE_1P10 TILT_1P00 PDC_240 BAND_MU_1P20
+ WIDE_MU_1P00 SAT5_0P20 RATIO_4P00 >> lna_v26_gain_nf_priority_summary.txt
echo SNUBBER_DISABLED_DEFAULT C_STAB_1f R_STAB_50 >> lna_v26_gain_nf_priority_summary.txt
echo ============================================================ >>
+ lna_v26_gain_nf_priority_summary.txt

echo ============================================================ >
+ lna_v26_gain_nf_priority_detailed.txt
echo LNA_V26_FINAL_FREQUENCY_DATA >> lna_v26_gain_nf_priority_detailed.txt
echo ============================================================ >>
+ lna_v26_gain_nf_priority_detailed.txt

* Global best initialized from the strongest V24 Stage-C region
set global_best_score = 1e99
set best_wcg = 160u
set best_vbcg = 2.05
set best_rd1 = 680
set best_l5 = 0.50u
set best_w5 = 25u
set best_vbicg = 1.65
set best_c12 = 47p
set best_req = 8
set best_ceq = 8.2p
set best_rd2 = 470
set best_cout = 47p
set best_rg = 0.25
set best_cstab = 1f
set best_rstab = 50
set best_wsf = 125u
set best_l6 = 0.50u
set best_w6 = 50u
set best_m6 = 3
set best_vbuf = 2.20

* =============================================================================
* STAGE A — XM2 COARSE HIGH-GAIN / LOW-NF SEARCH: 5 x 5 x 4 = 100
* =============================================================================
echo STAGE_A_XM2_COARSE >> lna_v26_gain_nf_priority_summary.txt
foreach wcg 140u 150u 160u 170u 180u
  foreach vbcg 1.95 2.00 2.05 2.10 2.15
    foreach rd1v 640 680 720 760

      alterparam W_CG = $best_wcg
      alterparam VBIAS_CG = $best_vbcg
      alterparam RD1 = $best_rd1
      alterparam L_BIAS_CG = $best_l5
      alterparam W_BIAS_CG = $best_w5
      alterparam VBIAS_ICG = $best_vbicg
      alterparam C12_VAL = $best_c12
      alterparam RS_EQ = $best_req
      alterparam CSEQ_VAL = $best_ceq
      alterparam RD2 = $best_rd2
      alterparam COUT_VAL = $best_cout
      alterparam RG_SF_VAL = $best_rg
      alterparam C_STAB_VAL = $best_cstab
      alterparam R_STAB_VAL = $best_rstab

alterparam W_CG = $wcg
alterparam VBIAS_CG = $vbcg
alterparam RD1 = $rd1v

      reset
      op

      * ----- DC operating point -----
      let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
      let vsrc1op = v(net3)
      let vx1op = v(net8)
      let v9op = v(net9)
      let vbufop = v(vbuf)

      let id1op = abs(@m.xm1.m0[id])
      let gm1op = @m.xm1.m0[gm]
      let gds1op = @m.xm1.m0[gds]
      let vgs1op = v(g_cs)-v(net3)
      let vgd1op = v(g_cs)-v(net8)
      let vgb1op = v(g_cs)
      let vds1op = v(net8)-v(net3)
      let vdsat1op = abs(@m.xm1.m0[vdsat])
      let sat1op = vds1op-vdsat1op

      let id2op = abs(@m.xm2.m0[id])
      let gm2op = @m.xm2.m0[gm]
      let gmb2op = @m.xm2.m0[gmbs]
      let gm2effop = gm2op+gmb2op
      let vds2op = v(d)-v(s)
      let vdsat2op = abs(@m.xm2.m0[vdsat])
      let sat2op = vds2op-vdsat2op

      let id3op = abs(@m.xm3.m0[id])
      let gm3op = @m.xm3.m0[gm]
      let gds3op = @m.xm3.m0[gds]
      let vds3op = v(vdcbias)-v(vbuf)
      let vdsat3op = abs(@m.xm3.m0[vdsat])
      let sat3op = vds3op-vdsat3op

      let id4op = abs(@m.xm4.m0[id])
      let gm4op = @m.xm4.m0[gm]
      let gds4op = @m.xm4.m0[gds]
      let vds4op = v(net9)-v(net8)
      let vdsat4op = abs(@m.xm4.m0[vdsat])
      let sat4op = vds4op-vdsat4op

      let id5op = abs(@m.xm5.m0[id])
      let gm5op = @m.xm5.m0[gm]
      let gds5op = @m.xm5.m0[gds]
      let vds5op = v(s)
      let vdsat5op = abs(@m.xm5.m0[vdsat])
      let sat5op = vds5op-vdsat5op

      let id6op = abs(@m.xm6.m0[id])
      let gm6op = @m.xm6.m0[gm]
      let gds6op = @m.xm6.m0[gds]
      let vds6op = v(vbuf)
      let vdsat6op = abs(@m.xm6.m0[vdsat])
      let sat6op = vds6op-vdsat6op

      let ratio25op = gm2effop/gm5op
      let ltotalop = 2.0e-9

      set op_pdc = $&pdcop
      set op_vsrc1 = $&vsrc1op
      set op_vx1 = $&vx1op
      set op_v9 = $&v9op
      set op_vbuf = $&vbufop
      set op_id1 = $&id1op
      set op_vgs1 = $&vgs1op
      set op_vgd1 = $&vgd1op
      set op_vgb1 = $&vgb1op
      set op_vds1 = $&vds1op
      set op_sat1 = $&sat1op
      set op_id2 = $&id2op
      set op_gm2eff = $&gm2effop
      set op_sat2 = $&sat2op
      set op_id3 = $&id3op
      set op_sat3 = $&sat3op
      set op_id4 = $&id4op
      set op_sat4 = $&sat4op
      set op_id5 = $&id5op
      set op_gm5 = $&gm5op
      set op_gds5 = $&gds5op
      set op_sat5 = $&sat5op
      set op_id6 = $&id6op
      set op_sat6 = $&sat6op
      set op_ratio25 = $&ratio25op
      set op_ltotal = $&ltotalop

      destroy $curplot

      * ----- Target-band S/noise/stability -----
      sp lin 101 2.30G 2.50G 1
      let s11db = db(s_1_1)
      let s21db = db(s_2_1)
      let s12db = db(s_1_2)
      let s22db = db(s_2_2)
      let nfdb = real(NF)

      let delta = s_1_1*s_2_2-s_1_2*s_2_1
      let md = mag(delta)
      let a11 = mag(s_1_1)
      let a12 = mag(s_1_2)
      let a21 = mag(s_2_1)
      let a22 = mag(s_2_2)
      let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
      let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

      let s11w = maximum(s11db)
      let s21m = minimum(s21db)
      let s21x = maximum(s21db)
      let ripple = s21x-s21m
      let tilt = abs(s21db[0]-s21db[100])
      let s22w = maximum(s22db)
      let nfw = maximum(nfdb)
      let mumin = minimum(mu)
      let mupmin = minimum(mup)
      let dmax = maximum(md)

      let passcount = 0
      if s11w <= target_s11
        let passcount = passcount+1
      end
      if s22w <= target_s22
        let passcount = passcount+1
      end
      if s21m >= target_gain
        let passcount = passcount+1
      end
      if nfw <= target_nf
        let passcount = passcount+1
      end
      if ripple <= target_ripple
        let passcount = passcount+1
      end
      if $op_pdc <= target_pdc
        let passcount = passcount+1
      end
      if mumin >= target_mu
        let passcount = passcount+1
      end
      if mupmin >= target_mu
        let passcount = passcount+1
      end
      if dmax < target_delta
        let passcount = passcount+1
      end

      let dcvalid = 1
      if $op_pdc > target_pdc
        let dcvalid = 0
      end
      if $op_sat1 < min_satmargin_xm1
        let dcvalid = 0
      end
      if $op_sat2 < min_satmargin_cg
        let dcvalid = 0
      end
      if $op_sat3 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat4 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat5 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_sat6 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_id5 < 0.0015
        let dcvalid = 0
      end
      if $op_id5 > 0.0060
        let dcvalid = 0
      end
      if $op_id6 < 0.015
        let dcvalid = 0
      end
      if $op_id6 > 0.060
        let dcvalid = 0
      end
      if abs($op_vgs1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgd1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgb1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vds1) > max_03v3_terminal
        let dcvalid = 0
      end
      if $op_ltotal > ltotal_limit
        let dcvalid = 0
      end
      if $op_v9 <= $op_vx1
        let dcvalid = 0
      end
      if $op_vx1 <= $op_vsrc1
        let dcvalid = 0
      end

      let passall = 1
      if passcount < 9
        let passall = 0
      end
      if dcvalid = 0
        let passall = 0
      end

      let pgain = 0
      let pnf = 0
      let pripple = 0
      let ptilt = 0
      let ps11 = 0
      let ps22 = 0
      let ppdc = 0
      let pmu = 0
      let pmup = 0
      let psat5 = 0
      let pratio = 0

      if s21m < margin_gain
        let pgain = margin_gain-s21m
      end
      if nfw > margin_nf
        let pnf = nfw-margin_nf
      end
      if ripple > margin_ripple
        let pripple = ripple-margin_ripple
      end
      if tilt > margin_tilt
        let ptilt = tilt-margin_tilt
      end
      if s11w > margin_s11
        let ps11 = s11w-margin_s11
      end
      if s22w > margin_s22
        let ps22 = s22w-margin_s22
      end
      if $op_pdc > margin_pdc
        let ppdc = $op_pdc-margin_pdc
      end
      if mumin < margin_mu_band
        let pmu = margin_mu_band-mumin
      end
      if mupmin < margin_mu_band
        let pmup = margin_mu_band-mupmin
      end
      if $op_sat5 < margin_sat5
        let psat5 = margin_sat5-$op_sat5
      end
      if $op_ratio25 < margin_ratio25
        let pratio = margin_ratio25-$op_ratio25
      end

      let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
      let score = score+25*ps11+25*ps22+0.02*ppdc
      let score = score+75*pmu+75*pmup
      let score = score+20*psat5+5*pratio
      let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

      if passall = 0
        let score = score+1e7
      end
      if dcvalid = 0
        let score = score+1e8
      end

      echo A_XM2 WCG $wcg VBCG $vbcg RD1 $rd1v SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount
+ PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w S21MIN $&s21m S21MAX $&s21x
+ RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin DELTA $&dmax >>
+ lna_v26_gain_nf_priority_summary.txt

      if score < $global_best_score
        set global_best_score = $&score
        set best_wcg = $wcg
      set best_vbcg = $vbcg
      set best_rd1 = $rd1v
      end

      destroy $curplot

    end
  end
end
echo GLOBAL_AFTER_A SCORE $global_best_score WCG $best_wcg VBCG $best_vbcg RD1 $best_rd1 >>
+ lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE B — XM5 LOW-NOISE SEARCH: 3 x 3 x 5 = 45
* =============================================================================
echo STAGE_B_XM5 >> lna_v26_gain_nf_priority_summary.txt
foreach l5 0.50u 0.60u 0.70u
  foreach w5 20u 25u 30u
    foreach vbicg 1.50 1.55 1.60 1.65 1.70

      alterparam W_CG = $best_wcg
      alterparam VBIAS_CG = $best_vbcg
      alterparam RD1 = $best_rd1
      alterparam L_BIAS_CG = $best_l5
      alterparam W_BIAS_CG = $best_w5
      alterparam VBIAS_ICG = $best_vbicg
      alterparam C12_VAL = $best_c12
      alterparam RS_EQ = $best_req
      alterparam CSEQ_VAL = $best_ceq
      alterparam RD2 = $best_rd2
      alterparam COUT_VAL = $best_cout
      alterparam RG_SF_VAL = $best_rg
      alterparam C_STAB_VAL = $best_cstab
      alterparam R_STAB_VAL = $best_rstab

alterparam L_BIAS_CG = $l5
alterparam W_BIAS_CG = $w5
alterparam VBIAS_ICG = $vbicg

      reset
      op

      * ----- DC operating point -----
      let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
      let vsrc1op = v(net3)
      let vx1op = v(net8)
      let v9op = v(net9)
      let vbufop = v(vbuf)

      let id1op = abs(@m.xm1.m0[id])
      let gm1op = @m.xm1.m0[gm]
      let gds1op = @m.xm1.m0[gds]
      let vgs1op = v(g_cs)-v(net3)
      let vgd1op = v(g_cs)-v(net8)
      let vgb1op = v(g_cs)
      let vds1op = v(net8)-v(net3)
      let vdsat1op = abs(@m.xm1.m0[vdsat])
      let sat1op = vds1op-vdsat1op

      let id2op = abs(@m.xm2.m0[id])
      let gm2op = @m.xm2.m0[gm]
      let gmb2op = @m.xm2.m0[gmbs]
      let gm2effop = gm2op+gmb2op
      let vds2op = v(d)-v(s)
      let vdsat2op = abs(@m.xm2.m0[vdsat])
      let sat2op = vds2op-vdsat2op

      let id3op = abs(@m.xm3.m0[id])
      let gm3op = @m.xm3.m0[gm]
      let gds3op = @m.xm3.m0[gds]
      let vds3op = v(vdcbias)-v(vbuf)
      let vdsat3op = abs(@m.xm3.m0[vdsat])
      let sat3op = vds3op-vdsat3op

      let id4op = abs(@m.xm4.m0[id])
      let gm4op = @m.xm4.m0[gm]
      let gds4op = @m.xm4.m0[gds]
      let vds4op = v(net9)-v(net8)
      let vdsat4op = abs(@m.xm4.m0[vdsat])
      let sat4op = vds4op-vdsat4op

      let id5op = abs(@m.xm5.m0[id])
      let gm5op = @m.xm5.m0[gm]
      let gds5op = @m.xm5.m0[gds]
      let vds5op = v(s)
      let vdsat5op = abs(@m.xm5.m0[vdsat])
      let sat5op = vds5op-vdsat5op

      let id6op = abs(@m.xm6.m0[id])
      let gm6op = @m.xm6.m0[gm]
      let gds6op = @m.xm6.m0[gds]
      let vds6op = v(vbuf)
      let vdsat6op = abs(@m.xm6.m0[vdsat])
      let sat6op = vds6op-vdsat6op

      let ratio25op = gm2effop/gm5op
      let ltotalop = 2.0e-9

      set op_pdc = $&pdcop
      set op_vsrc1 = $&vsrc1op
      set op_vx1 = $&vx1op
      set op_v9 = $&v9op
      set op_vbuf = $&vbufop
      set op_id1 = $&id1op
      set op_vgs1 = $&vgs1op
      set op_vgd1 = $&vgd1op
      set op_vgb1 = $&vgb1op
      set op_vds1 = $&vds1op
      set op_sat1 = $&sat1op
      set op_id2 = $&id2op
      set op_gm2eff = $&gm2effop
      set op_sat2 = $&sat2op
      set op_id3 = $&id3op
      set op_sat3 = $&sat3op
      set op_id4 = $&id4op
      set op_sat4 = $&sat4op
      set op_id5 = $&id5op
      set op_gm5 = $&gm5op
      set op_gds5 = $&gds5op
      set op_sat5 = $&sat5op
      set op_id6 = $&id6op
      set op_sat6 = $&sat6op
      set op_ratio25 = $&ratio25op
      set op_ltotal = $&ltotalop

      destroy $curplot

      * ----- Target-band S/noise/stability -----
      sp lin 101 2.30G 2.50G 1
      let s11db = db(s_1_1)
      let s21db = db(s_2_1)
      let s12db = db(s_1_2)
      let s22db = db(s_2_2)
      let nfdb = real(NF)

      let delta = s_1_1*s_2_2-s_1_2*s_2_1
      let md = mag(delta)
      let a11 = mag(s_1_1)
      let a12 = mag(s_1_2)
      let a21 = mag(s_2_1)
      let a22 = mag(s_2_2)
      let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
      let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

      let s11w = maximum(s11db)
      let s21m = minimum(s21db)
      let s21x = maximum(s21db)
      let ripple = s21x-s21m
      let tilt = abs(s21db[0]-s21db[100])
      let s22w = maximum(s22db)
      let nfw = maximum(nfdb)
      let mumin = minimum(mu)
      let mupmin = minimum(mup)
      let dmax = maximum(md)

      let passcount = 0
      if s11w <= target_s11
        let passcount = passcount+1
      end
      if s22w <= target_s22
        let passcount = passcount+1
      end
      if s21m >= target_gain
        let passcount = passcount+1
      end
      if nfw <= target_nf
        let passcount = passcount+1
      end
      if ripple <= target_ripple
        let passcount = passcount+1
      end
      if $op_pdc <= target_pdc
        let passcount = passcount+1
      end
      if mumin >= target_mu
        let passcount = passcount+1
      end
      if mupmin >= target_mu
        let passcount = passcount+1
      end
      if dmax < target_delta
        let passcount = passcount+1
      end

      let dcvalid = 1
      if $op_pdc > target_pdc
        let dcvalid = 0
      end
      if $op_sat1 < min_satmargin_xm1
        let dcvalid = 0
      end
      if $op_sat2 < min_satmargin_cg
        let dcvalid = 0
      end
      if $op_sat3 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat4 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat5 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_sat6 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_id5 < 0.0015
        let dcvalid = 0
      end
      if $op_id5 > 0.0060
        let dcvalid = 0
      end
      if $op_id6 < 0.015
        let dcvalid = 0
      end
      if $op_id6 > 0.060
        let dcvalid = 0
      end
      if abs($op_vgs1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgd1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgb1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vds1) > max_03v3_terminal
        let dcvalid = 0
      end
      if $op_ltotal > ltotal_limit
        let dcvalid = 0
      end
      if $op_v9 <= $op_vx1
        let dcvalid = 0
      end
      if $op_vx1 <= $op_vsrc1
        let dcvalid = 0
      end

      let passall = 1
      if passcount < 9
        let passall = 0
      end
      if dcvalid = 0
        let passall = 0
      end

      let pgain = 0
      let pnf = 0
      let pripple = 0
      let ptilt = 0
      let ps11 = 0
      let ps22 = 0
      let ppdc = 0
      let pmu = 0
      let pmup = 0
      let psat5 = 0
      let pratio = 0

      if s21m < margin_gain
        let pgain = margin_gain-s21m
      end
      if nfw > margin_nf
        let pnf = nfw-margin_nf
      end
      if ripple > margin_ripple
        let pripple = ripple-margin_ripple
      end
      if tilt > margin_tilt
        let ptilt = tilt-margin_tilt
      end
      if s11w > margin_s11
        let ps11 = s11w-margin_s11
      end
      if s22w > margin_s22
        let ps22 = s22w-margin_s22
      end
      if $op_pdc > margin_pdc
        let ppdc = $op_pdc-margin_pdc
      end
      if mumin < margin_mu_band
        let pmu = margin_mu_band-mumin
      end
      if mupmin < margin_mu_band
        let pmup = margin_mu_band-mupmin
      end
      if $op_sat5 < margin_sat5
        let psat5 = margin_sat5-$op_sat5
      end
      if $op_ratio25 < margin_ratio25
        let pratio = margin_ratio25-$op_ratio25
      end

      let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
      let score = score+25*ps11+25*ps22+0.02*ppdc
      let score = score+75*pmu+75*pmup
      let score = score+20*psat5+5*pratio
      let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

      if passall = 0
        let score = score+1e7
      end
      if dcvalid = 0
        let score = score+1e8
      end

      echo B_XM5 L5 $l5 W5 $w5 VBICG $vbicg SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount
+ PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w S21MIN $&s21m S21MAX $&s21x
+ RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin DELTA $&dmax >>
+ lna_v26_gain_nf_priority_summary.txt

      if score < $global_best_score
        set global_best_score = $&score
        set best_l5 = $l5
      set best_w5 = $w5
      set best_vbicg = $vbicg
      end

      destroy $curplot

    end
  end
end
echo GLOBAL_AFTER_B SCORE $global_best_score L5 $best_l5 W5 $best_w5 VBICG $best_vbicg >>
+ lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE C — JOINT XM2/XM5 HIGH-GAIN LOW-NF SEARCH: 5 x 5 x 4 x 3 x 4 = 1200
* =============================================================================
echo STAGE_C_JOINT_XM2_XM5 >> lna_v26_gain_nf_priority_summary.txt
foreach wcg 140u 150u 160u 170u 180u
  foreach vbcg 1.95 2.00 2.05 2.10 2.15
    foreach rd1v 640 680 720 760
      foreach w5 20u 25u 30u
        foreach vbicg 1.50 1.55 1.60 1.65

          alterparam W_CG = $best_wcg
          alterparam VBIAS_CG = $best_vbcg
          alterparam RD1 = $best_rd1
          alterparam L_BIAS_CG = $best_l5
          alterparam W_BIAS_CG = $best_w5
          alterparam VBIAS_ICG = $best_vbicg
          alterparam C12_VAL = $best_c12
          alterparam RS_EQ = $best_req
          alterparam CSEQ_VAL = $best_ceq
          alterparam RD2 = $best_rd2
          alterparam COUT_VAL = $best_cout
          alterparam RG_SF_VAL = $best_rg
          alterparam C_STAB_VAL = $best_cstab
          alterparam R_STAB_VAL = $best_rstab

alterparam W_CG = $wcg
alterparam VBIAS_CG = $vbcg
alterparam RD1 = $rd1v
alterparam L_BIAS_CG = $best_l5
alterparam W_BIAS_CG = $w5
alterparam VBIAS_ICG = $vbicg

          reset
          op

          * ----- DC operating point -----
          let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
          let vsrc1op = v(net3)
          let vx1op = v(net8)
          let v9op = v(net9)
          let vbufop = v(vbuf)

          let id1op = abs(@m.xm1.m0[id])
          let gm1op = @m.xm1.m0[gm]
          let gds1op = @m.xm1.m0[gds]
          let vgs1op = v(g_cs)-v(net3)
          let vgd1op = v(g_cs)-v(net8)
          let vgb1op = v(g_cs)
          let vds1op = v(net8)-v(net3)
          let vdsat1op = abs(@m.xm1.m0[vdsat])
          let sat1op = vds1op-vdsat1op

          let id2op = abs(@m.xm2.m0[id])
          let gm2op = @m.xm2.m0[gm]
          let gmb2op = @m.xm2.m0[gmbs]
          let gm2effop = gm2op+gmb2op
          let vds2op = v(d)-v(s)
          let vdsat2op = abs(@m.xm2.m0[vdsat])
          let sat2op = vds2op-vdsat2op

          let id3op = abs(@m.xm3.m0[id])
          let gm3op = @m.xm3.m0[gm]
          let gds3op = @m.xm3.m0[gds]
          let vds3op = v(vdcbias)-v(vbuf)
          let vdsat3op = abs(@m.xm3.m0[vdsat])
          let sat3op = vds3op-vdsat3op

          let id4op = abs(@m.xm4.m0[id])
          let gm4op = @m.xm4.m0[gm]
          let gds4op = @m.xm4.m0[gds]
          let vds4op = v(net9)-v(net8)
          let vdsat4op = abs(@m.xm4.m0[vdsat])
          let sat4op = vds4op-vdsat4op

          let id5op = abs(@m.xm5.m0[id])
          let gm5op = @m.xm5.m0[gm]
          let gds5op = @m.xm5.m0[gds]
          let vds5op = v(s)
          let vdsat5op = abs(@m.xm5.m0[vdsat])
          let sat5op = vds5op-vdsat5op

          let id6op = abs(@m.xm6.m0[id])
          let gm6op = @m.xm6.m0[gm]
          let gds6op = @m.xm6.m0[gds]
          let vds6op = v(vbuf)
          let vdsat6op = abs(@m.xm6.m0[vdsat])
          let sat6op = vds6op-vdsat6op

          let ratio25op = gm2effop/gm5op
          let ltotalop = 2.0e-9

          set op_pdc = $&pdcop
          set op_vsrc1 = $&vsrc1op
          set op_vx1 = $&vx1op
          set op_v9 = $&v9op
          set op_vbuf = $&vbufop
          set op_id1 = $&id1op
          set op_vgs1 = $&vgs1op
          set op_vgd1 = $&vgd1op
          set op_vgb1 = $&vgb1op
          set op_vds1 = $&vds1op
          set op_sat1 = $&sat1op
          set op_id2 = $&id2op
          set op_gm2eff = $&gm2effop
          set op_sat2 = $&sat2op
          set op_id3 = $&id3op
          set op_sat3 = $&sat3op
          set op_id4 = $&id4op
          set op_sat4 = $&sat4op
          set op_id5 = $&id5op
          set op_gm5 = $&gm5op
          set op_gds5 = $&gds5op
          set op_sat5 = $&sat5op
          set op_id6 = $&id6op
          set op_sat6 = $&sat6op
          set op_ratio25 = $&ratio25op
          set op_ltotal = $&ltotalop

          destroy $curplot

          * ----- Target-band S/noise/stability -----
          sp lin 101 2.30G 2.50G 1
          let s11db = db(s_1_1)
          let s21db = db(s_2_1)
          let s12db = db(s_1_2)
          let s22db = db(s_2_2)
          let nfdb = real(NF)

          let delta = s_1_1*s_2_2-s_1_2*s_2_1
          let md = mag(delta)
          let a11 = mag(s_1_1)
          let a12 = mag(s_1_2)
          let a21 = mag(s_2_1)
          let a22 = mag(s_2_2)
          let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
          let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

          let s11w = maximum(s11db)
          let s21m = minimum(s21db)
          let s21x = maximum(s21db)
          let ripple = s21x-s21m
          let tilt = abs(s21db[0]-s21db[100])
          let s22w = maximum(s22db)
          let nfw = maximum(nfdb)
          let mumin = minimum(mu)
          let mupmin = minimum(mup)
          let dmax = maximum(md)

          let passcount = 0
          if s11w <= target_s11
            let passcount = passcount+1
          end
          if s22w <= target_s22
            let passcount = passcount+1
          end
          if s21m >= target_gain
            let passcount = passcount+1
          end
          if nfw <= target_nf
            let passcount = passcount+1
          end
          if ripple <= target_ripple
            let passcount = passcount+1
          end
          if $op_pdc <= target_pdc
            let passcount = passcount+1
          end
          if mumin >= target_mu
            let passcount = passcount+1
          end
          if mupmin >= target_mu
            let passcount = passcount+1
          end
          if dmax < target_delta
            let passcount = passcount+1
          end

          let dcvalid = 1
          if $op_pdc > target_pdc
            let dcvalid = 0
          end
          if $op_sat1 < min_satmargin_xm1
            let dcvalid = 0
          end
          if $op_sat2 < min_satmargin_cg
            let dcvalid = 0
          end
          if $op_sat3 < min_satmargin_core
            let dcvalid = 0
          end
          if $op_sat4 < min_satmargin_core
            let dcvalid = 0
          end
          if $op_sat5 < min_satmargin_sink
            let dcvalid = 0
          end
          if $op_sat6 < min_satmargin_sink
            let dcvalid = 0
          end
          if $op_id5 < 0.0015
            let dcvalid = 0
          end
          if $op_id5 > 0.0060
            let dcvalid = 0
          end
          if $op_id6 < 0.015
            let dcvalid = 0
          end
          if $op_id6 > 0.060
            let dcvalid = 0
          end
          if abs($op_vgs1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vgd1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vgb1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vds1) > max_03v3_terminal
            let dcvalid = 0
          end
          if $op_ltotal > ltotal_limit
            let dcvalid = 0
          end
          if $op_v9 <= $op_vx1
            let dcvalid = 0
          end
          if $op_vx1 <= $op_vsrc1
            let dcvalid = 0
          end

          let passall = 1
          if passcount < 9
            let passall = 0
          end
          if dcvalid = 0
            let passall = 0
          end

          let pgain = 0
          let pnf = 0
          let pripple = 0
          let ptilt = 0
          let ps11 = 0
          let ps22 = 0
          let ppdc = 0
          let pmu = 0
          let pmup = 0
          let psat5 = 0
          let pratio = 0

          if s21m < margin_gain
            let pgain = margin_gain-s21m
          end
          if nfw > margin_nf
            let pnf = nfw-margin_nf
          end
          if ripple > margin_ripple
            let pripple = ripple-margin_ripple
          end
          if tilt > margin_tilt
            let ptilt = tilt-margin_tilt
          end
          if s11w > margin_s11
            let ps11 = s11w-margin_s11
          end
          if s22w > margin_s22
            let ps22 = s22w-margin_s22
          end
          if $op_pdc > margin_pdc
            let ppdc = $op_pdc-margin_pdc
          end
          if mumin < margin_mu_band
            let pmu = margin_mu_band-mumin
          end
          if mupmin < margin_mu_band
            let pmup = margin_mu_band-mupmin
          end
          if $op_sat5 < margin_sat5
            let psat5 = margin_sat5-$op_sat5
          end
          if $op_ratio25 < margin_ratio25
            let pratio = margin_ratio25-$op_ratio25
          end

          let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
          let score = score+25*ps11+25*ps22+0.02*ppdc
          let score = score+75*pmu+75*pmup
          let score = score+20*psat5+5*pratio
          let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

          if passall = 0
            let score = score+1e7
          end
          if dcvalid = 0
            let score = score+1e8
          end

          echo C_JOINT WCG $wcg VBCG $vbcg RD1 $rd1v W5 $w5 VBICG $vbicg SCORE $&score DCVALID
+ $&dcvalid PASSCOUNT $&passcount PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w
+ S21MIN $&s21m S21MAX $&s21x RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin
+ DELTA $&dmax >> lna_v26_gain_nf_priority_summary.txt

          if score < $global_best_score
            set global_best_score = $&score
            set best_wcg = $wcg
          set best_vbcg = $vbcg
          set best_rd1 = $rd1v
          set best_w5 = $w5
          set best_vbicg = $vbicg
          end

          destroy $curplot

        end
      end
    end
  end
end
echo GLOBAL_AFTER_C SCORE $global_best_score WCG $best_wcg VBCG $best_vbcg RD1 $best_rd1 L5 $best_l5
+ W5 $best_w5 VBICG $best_vbicg >> lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE D — C12 + SOURCE-EQUALIZER GAIN RECOVERY: 5 x 6 x 6 = 180
* =============================================================================
echo STAGE_D_C12_REQ_CEQ >> lna_v26_gain_nf_priority_summary.txt
foreach c12v 22p 33p 47p 68p 100p
  foreach reqv 5 6 7 8 9 10
    foreach ceqv 6.8p 7.5p 8.2p 9.1p 10p 12p

      alterparam W_CG = $best_wcg
      alterparam VBIAS_CG = $best_vbcg
      alterparam RD1 = $best_rd1
      alterparam L_BIAS_CG = $best_l5
      alterparam W_BIAS_CG = $best_w5
      alterparam VBIAS_ICG = $best_vbicg
      alterparam C12_VAL = $best_c12
      alterparam RS_EQ = $best_req
      alterparam CSEQ_VAL = $best_ceq
      alterparam RD2 = $best_rd2
      alterparam COUT_VAL = $best_cout
      alterparam RG_SF_VAL = $best_rg
      alterparam C_STAB_VAL = $best_cstab
      alterparam R_STAB_VAL = $best_rstab

alterparam C12_VAL = $c12v
alterparam RS_EQ = $reqv
alterparam CSEQ_VAL = $ceqv

      reset
      op

      * ----- DC operating point -----
      let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
      let vsrc1op = v(net3)
      let vx1op = v(net8)
      let v9op = v(net9)
      let vbufop = v(vbuf)

      let id1op = abs(@m.xm1.m0[id])
      let gm1op = @m.xm1.m0[gm]
      let gds1op = @m.xm1.m0[gds]
      let vgs1op = v(g_cs)-v(net3)
      let vgd1op = v(g_cs)-v(net8)
      let vgb1op = v(g_cs)
      let vds1op = v(net8)-v(net3)
      let vdsat1op = abs(@m.xm1.m0[vdsat])
      let sat1op = vds1op-vdsat1op

      let id2op = abs(@m.xm2.m0[id])
      let gm2op = @m.xm2.m0[gm]
      let gmb2op = @m.xm2.m0[gmbs]
      let gm2effop = gm2op+gmb2op
      let vds2op = v(d)-v(s)
      let vdsat2op = abs(@m.xm2.m0[vdsat])
      let sat2op = vds2op-vdsat2op

      let id3op = abs(@m.xm3.m0[id])
      let gm3op = @m.xm3.m0[gm]
      let gds3op = @m.xm3.m0[gds]
      let vds3op = v(vdcbias)-v(vbuf)
      let vdsat3op = abs(@m.xm3.m0[vdsat])
      let sat3op = vds3op-vdsat3op

      let id4op = abs(@m.xm4.m0[id])
      let gm4op = @m.xm4.m0[gm]
      let gds4op = @m.xm4.m0[gds]
      let vds4op = v(net9)-v(net8)
      let vdsat4op = abs(@m.xm4.m0[vdsat])
      let sat4op = vds4op-vdsat4op

      let id5op = abs(@m.xm5.m0[id])
      let gm5op = @m.xm5.m0[gm]
      let gds5op = @m.xm5.m0[gds]
      let vds5op = v(s)
      let vdsat5op = abs(@m.xm5.m0[vdsat])
      let sat5op = vds5op-vdsat5op

      let id6op = abs(@m.xm6.m0[id])
      let gm6op = @m.xm6.m0[gm]
      let gds6op = @m.xm6.m0[gds]
      let vds6op = v(vbuf)
      let vdsat6op = abs(@m.xm6.m0[vdsat])
      let sat6op = vds6op-vdsat6op

      let ratio25op = gm2effop/gm5op
      let ltotalop = 2.0e-9

      set op_pdc = $&pdcop
      set op_vsrc1 = $&vsrc1op
      set op_vx1 = $&vx1op
      set op_v9 = $&v9op
      set op_vbuf = $&vbufop
      set op_id1 = $&id1op
      set op_vgs1 = $&vgs1op
      set op_vgd1 = $&vgd1op
      set op_vgb1 = $&vgb1op
      set op_vds1 = $&vds1op
      set op_sat1 = $&sat1op
      set op_id2 = $&id2op
      set op_gm2eff = $&gm2effop
      set op_sat2 = $&sat2op
      set op_id3 = $&id3op
      set op_sat3 = $&sat3op
      set op_id4 = $&id4op
      set op_sat4 = $&sat4op
      set op_id5 = $&id5op
      set op_gm5 = $&gm5op
      set op_gds5 = $&gds5op
      set op_sat5 = $&sat5op
      set op_id6 = $&id6op
      set op_sat6 = $&sat6op
      set op_ratio25 = $&ratio25op
      set op_ltotal = $&ltotalop

      destroy $curplot

      * ----- Target-band S/noise/stability -----
      sp lin 101 2.30G 2.50G 1
      let s11db = db(s_1_1)
      let s21db = db(s_2_1)
      let s12db = db(s_1_2)
      let s22db = db(s_2_2)
      let nfdb = real(NF)

      let delta = s_1_1*s_2_2-s_1_2*s_2_1
      let md = mag(delta)
      let a11 = mag(s_1_1)
      let a12 = mag(s_1_2)
      let a21 = mag(s_2_1)
      let a22 = mag(s_2_2)
      let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
      let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

      let s11w = maximum(s11db)
      let s21m = minimum(s21db)
      let s21x = maximum(s21db)
      let ripple = s21x-s21m
      let tilt = abs(s21db[0]-s21db[100])
      let s22w = maximum(s22db)
      let nfw = maximum(nfdb)
      let mumin = minimum(mu)
      let mupmin = minimum(mup)
      let dmax = maximum(md)

      let passcount = 0
      if s11w <= target_s11
        let passcount = passcount+1
      end
      if s22w <= target_s22
        let passcount = passcount+1
      end
      if s21m >= target_gain
        let passcount = passcount+1
      end
      if nfw <= target_nf
        let passcount = passcount+1
      end
      if ripple <= target_ripple
        let passcount = passcount+1
      end
      if $op_pdc <= target_pdc
        let passcount = passcount+1
      end
      if mumin >= target_mu
        let passcount = passcount+1
      end
      if mupmin >= target_mu
        let passcount = passcount+1
      end
      if dmax < target_delta
        let passcount = passcount+1
      end

      let dcvalid = 1
      if $op_pdc > target_pdc
        let dcvalid = 0
      end
      if $op_sat1 < min_satmargin_xm1
        let dcvalid = 0
      end
      if $op_sat2 < min_satmargin_cg
        let dcvalid = 0
      end
      if $op_sat3 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat4 < min_satmargin_core
        let dcvalid = 0
      end
      if $op_sat5 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_sat6 < min_satmargin_sink
        let dcvalid = 0
      end
      if $op_id5 < 0.0015
        let dcvalid = 0
      end
      if $op_id5 > 0.0060
        let dcvalid = 0
      end
      if $op_id6 < 0.015
        let dcvalid = 0
      end
      if $op_id6 > 0.060
        let dcvalid = 0
      end
      if abs($op_vgs1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgd1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vgb1) > max_03v3_terminal
        let dcvalid = 0
      end
      if abs($op_vds1) > max_03v3_terminal
        let dcvalid = 0
      end
      if $op_ltotal > ltotal_limit
        let dcvalid = 0
      end
      if $op_v9 <= $op_vx1
        let dcvalid = 0
      end
      if $op_vx1 <= $op_vsrc1
        let dcvalid = 0
      end

      let passall = 1
      if passcount < 9
        let passall = 0
      end
      if dcvalid = 0
        let passall = 0
      end

      let pgain = 0
      let pnf = 0
      let pripple = 0
      let ptilt = 0
      let ps11 = 0
      let ps22 = 0
      let ppdc = 0
      let pmu = 0
      let pmup = 0
      let psat5 = 0
      let pratio = 0

      if s21m < margin_gain
        let pgain = margin_gain-s21m
      end
      if nfw > margin_nf
        let pnf = nfw-margin_nf
      end
      if ripple > margin_ripple
        let pripple = ripple-margin_ripple
      end
      if tilt > margin_tilt
        let ptilt = tilt-margin_tilt
      end
      if s11w > margin_s11
        let ps11 = s11w-margin_s11
      end
      if s22w > margin_s22
        let ps22 = s22w-margin_s22
      end
      if $op_pdc > margin_pdc
        let ppdc = $op_pdc-margin_pdc
      end
      if mumin < margin_mu_band
        let pmu = margin_mu_band-mumin
      end
      if mupmin < margin_mu_band
        let pmup = margin_mu_band-mupmin
      end
      if $op_sat5 < margin_sat5
        let psat5 = margin_sat5-$op_sat5
      end
      if $op_ratio25 < margin_ratio25
        let pratio = margin_ratio25-$op_ratio25
      end

      let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
      let score = score+25*ps11+25*ps22+0.02*ppdc
      let score = score+75*pmu+75*pmup
      let score = score+20*psat5+5*pratio
      let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

      if passall = 0
        let score = score+1e7
      end
      if dcvalid = 0
        let score = score+1e8
      end

      echo D_EQ C12 $c12v REQ $reqv CEQ $ceqv SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount
+ PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w S21MIN $&s21m S21MAX $&s21x
+ RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin DELTA $&dmax >>
+ lna_v26_gain_nf_priority_summary.txt

      if score < $global_best_score
        set global_best_score = $&score
        set best_c12 = $c12v
      set best_req = $reqv
      set best_ceq = $ceqv
      end

      destroy $curplot

    end
  end
end
echo GLOBAL_AFTER_D SCORE $global_best_score C12 $best_c12 REQ $best_req CEQ $best_ceq >>
+ lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE E — RD2 / COUT GAIN-RECOVERY SEARCH: 6 x 4 = 24
* =============================================================================
echo STAGE_E_RD2_COUT >> lna_v26_gain_nf_priority_summary.txt
foreach rd2v 450 470 490 510 530 560
  foreach coutv 39p 47p 56p 68p

    alterparam W_CG = $best_wcg
    alterparam VBIAS_CG = $best_vbcg
    alterparam RD1 = $best_rd1
    alterparam L_BIAS_CG = $best_l5
    alterparam W_BIAS_CG = $best_w5
    alterparam VBIAS_ICG = $best_vbicg
    alterparam C12_VAL = $best_c12
    alterparam RS_EQ = $best_req
    alterparam CSEQ_VAL = $best_ceq
    alterparam RD2 = $best_rd2
    alterparam COUT_VAL = $best_cout
    alterparam RG_SF_VAL = $best_rg
    alterparam C_STAB_VAL = $best_cstab
    alterparam R_STAB_VAL = $best_rstab

alterparam RD2 = $rd2v
alterparam COUT_VAL = $coutv

    reset
    op

    * ----- DC operating point -----
    let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
    let vsrc1op = v(net3)
    let vx1op = v(net8)
    let v9op = v(net9)
    let vbufop = v(vbuf)

    let id1op = abs(@m.xm1.m0[id])
    let gm1op = @m.xm1.m0[gm]
    let gds1op = @m.xm1.m0[gds]
    let vgs1op = v(g_cs)-v(net3)
    let vgd1op = v(g_cs)-v(net8)
    let vgb1op = v(g_cs)
    let vds1op = v(net8)-v(net3)
    let vdsat1op = abs(@m.xm1.m0[vdsat])
    let sat1op = vds1op-vdsat1op

    let id2op = abs(@m.xm2.m0[id])
    let gm2op = @m.xm2.m0[gm]
    let gmb2op = @m.xm2.m0[gmbs]
    let gm2effop = gm2op+gmb2op
    let vds2op = v(d)-v(s)
    let vdsat2op = abs(@m.xm2.m0[vdsat])
    let sat2op = vds2op-vdsat2op

    let id3op = abs(@m.xm3.m0[id])
    let gm3op = @m.xm3.m0[gm]
    let gds3op = @m.xm3.m0[gds]
    let vds3op = v(vdcbias)-v(vbuf)
    let vdsat3op = abs(@m.xm3.m0[vdsat])
    let sat3op = vds3op-vdsat3op

    let id4op = abs(@m.xm4.m0[id])
    let gm4op = @m.xm4.m0[gm]
    let gds4op = @m.xm4.m0[gds]
    let vds4op = v(net9)-v(net8)
    let vdsat4op = abs(@m.xm4.m0[vdsat])
    let sat4op = vds4op-vdsat4op

    let id5op = abs(@m.xm5.m0[id])
    let gm5op = @m.xm5.m0[gm]
    let gds5op = @m.xm5.m0[gds]
    let vds5op = v(s)
    let vdsat5op = abs(@m.xm5.m0[vdsat])
    let sat5op = vds5op-vdsat5op

    let id6op = abs(@m.xm6.m0[id])
    let gm6op = @m.xm6.m0[gm]
    let gds6op = @m.xm6.m0[gds]
    let vds6op = v(vbuf)
    let vdsat6op = abs(@m.xm6.m0[vdsat])
    let sat6op = vds6op-vdsat6op

    let ratio25op = gm2effop/gm5op
    let ltotalop = 2.0e-9

    set op_pdc = $&pdcop
    set op_vsrc1 = $&vsrc1op
    set op_vx1 = $&vx1op
    set op_v9 = $&v9op
    set op_vbuf = $&vbufop
    set op_id1 = $&id1op
    set op_vgs1 = $&vgs1op
    set op_vgd1 = $&vgd1op
    set op_vgb1 = $&vgb1op
    set op_vds1 = $&vds1op
    set op_sat1 = $&sat1op
    set op_id2 = $&id2op
    set op_gm2eff = $&gm2effop
    set op_sat2 = $&sat2op
    set op_id3 = $&id3op
    set op_sat3 = $&sat3op
    set op_id4 = $&id4op
    set op_sat4 = $&sat4op
    set op_id5 = $&id5op
    set op_gm5 = $&gm5op
    set op_gds5 = $&gds5op
    set op_sat5 = $&sat5op
    set op_id6 = $&id6op
    set op_sat6 = $&sat6op
    set op_ratio25 = $&ratio25op
    set op_ltotal = $&ltotalop

    destroy $curplot

    * ----- Target-band S/noise/stability -----
    sp lin 101 2.30G 2.50G 1
    let s11db = db(s_1_1)
    let s21db = db(s_2_1)
    let s12db = db(s_1_2)
    let s22db = db(s_2_2)
    let nfdb = real(NF)

    let delta = s_1_1*s_2_2-s_1_2*s_2_1
    let md = mag(delta)
    let a11 = mag(s_1_1)
    let a12 = mag(s_1_2)
    let a21 = mag(s_2_1)
    let a22 = mag(s_2_2)
    let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
    let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

    let s11w = maximum(s11db)
    let s21m = minimum(s21db)
    let s21x = maximum(s21db)
    let ripple = s21x-s21m
    let tilt = abs(s21db[0]-s21db[100])
    let s22w = maximum(s22db)
    let nfw = maximum(nfdb)
    let mumin = minimum(mu)
    let mupmin = minimum(mup)
    let dmax = maximum(md)

    let passcount = 0
    if s11w <= target_s11
      let passcount = passcount+1
    end
    if s22w <= target_s22
      let passcount = passcount+1
    end
    if s21m >= target_gain
      let passcount = passcount+1
    end
    if nfw <= target_nf
      let passcount = passcount+1
    end
    if ripple <= target_ripple
      let passcount = passcount+1
    end
    if $op_pdc <= target_pdc
      let passcount = passcount+1
    end
    if mumin >= target_mu
      let passcount = passcount+1
    end
    if mupmin >= target_mu
      let passcount = passcount+1
    end
    if dmax < target_delta
      let passcount = passcount+1
    end

    let dcvalid = 1
    if $op_pdc > target_pdc
      let dcvalid = 0
    end
    if $op_sat1 < min_satmargin_xm1
      let dcvalid = 0
    end
    if $op_sat2 < min_satmargin_cg
      let dcvalid = 0
    end
    if $op_sat3 < min_satmargin_core
      let dcvalid = 0
    end
    if $op_sat4 < min_satmargin_core
      let dcvalid = 0
    end
    if $op_sat5 < min_satmargin_sink
      let dcvalid = 0
    end
    if $op_sat6 < min_satmargin_sink
      let dcvalid = 0
    end
    if $op_id5 < 0.0015
      let dcvalid = 0
    end
    if $op_id5 > 0.0060
      let dcvalid = 0
    end
    if $op_id6 < 0.015
      let dcvalid = 0
    end
    if $op_id6 > 0.060
      let dcvalid = 0
    end
    if abs($op_vgs1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vgd1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vgb1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vds1) > max_03v3_terminal
      let dcvalid = 0
    end
    if $op_ltotal > ltotal_limit
      let dcvalid = 0
    end
    if $op_v9 <= $op_vx1
      let dcvalid = 0
    end
    if $op_vx1 <= $op_vsrc1
      let dcvalid = 0
    end

    let passall = 1
    if passcount < 9
      let passall = 0
    end
    if dcvalid = 0
      let passall = 0
    end

    let pgain = 0
    let pnf = 0
    let pripple = 0
    let ptilt = 0
    let ps11 = 0
    let ps22 = 0
    let ppdc = 0
    let pmu = 0
    let pmup = 0
    let psat5 = 0
    let pratio = 0

    if s21m < margin_gain
      let pgain = margin_gain-s21m
    end
    if nfw > margin_nf
      let pnf = nfw-margin_nf
    end
    if ripple > margin_ripple
      let pripple = ripple-margin_ripple
    end
    if tilt > margin_tilt
      let ptilt = tilt-margin_tilt
    end
    if s11w > margin_s11
      let ps11 = s11w-margin_s11
    end
    if s22w > margin_s22
      let ps22 = s22w-margin_s22
    end
    if $op_pdc > margin_pdc
      let ppdc = $op_pdc-margin_pdc
    end
    if mumin < margin_mu_band
      let pmu = margin_mu_band-mumin
    end
    if mupmin < margin_mu_band
      let pmup = margin_mu_band-mupmin
    end
    if $op_sat5 < margin_sat5
      let psat5 = margin_sat5-$op_sat5
    end
    if $op_ratio25 < margin_ratio25
      let pratio = margin_ratio25-$op_ratio25
    end

    let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
    let score = score+25*ps11+25*ps22+0.02*ppdc
    let score = score+75*pmu+75*pmup
    let score = score+20*psat5+5*pratio
    let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

    if passall = 0
      let score = score+1e7
    end
    if dcvalid = 0
      let score = score+1e8
    end

    echo E_LOAD RD2 $rd2v COUT $coutv SCORE $&score DCVALID $&dcvalid PASSCOUNT $&passcount PASSALL
+ $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w S21MIN $&s21m S21MAX $&s21x RIPPLE
+ $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin DELTA $&dmax >>
+ lna_v26_gain_nf_priority_summary.txt

    if score < $global_best_score
      set global_best_score = $&score
      set best_rd2 = $rd2v
    set best_cout = $coutv
    end

    destroy $curplot

  end
end
echo GLOBAL_AFTER_E SCORE $global_best_score RD2 $best_rd2 COUT $best_cout >>
+ lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE F — JOINT C12 / EQ / LOAD HIGH-GAIN SEARCH: 5 x 6 x 6 x 6 x 3 = 3240
* =============================================================================
echo STAGE_F_JOINT_EQUALIZATION_LOAD >> lna_v26_gain_nf_priority_summary.txt
foreach c12v 22p 33p 47p 68p 100p
  foreach reqv 5 6 7 8 9 10
    foreach ceqv 6.8p 7.5p 8.2p 9.1p 10p 12p
      foreach rd2v 450 470 490 510 530 560
        foreach coutv 39p 47p 56p

          alterparam W_CG = $best_wcg
          alterparam VBIAS_CG = $best_vbcg
          alterparam RD1 = $best_rd1
          alterparam L_BIAS_CG = $best_l5
          alterparam W_BIAS_CG = $best_w5
          alterparam VBIAS_ICG = $best_vbicg
          alterparam C12_VAL = $best_c12
          alterparam RS_EQ = $best_req
          alterparam CSEQ_VAL = $best_ceq
          alterparam RD2 = $best_rd2
          alterparam COUT_VAL = $best_cout
          alterparam RG_SF_VAL = $best_rg
          alterparam C_STAB_VAL = $best_cstab
          alterparam R_STAB_VAL = $best_rstab

alterparam C12_VAL = $c12v
alterparam RS_EQ = $reqv
alterparam CSEQ_VAL = $ceqv
alterparam RD2 = $rd2v
alterparam COUT_VAL = $coutv

          reset
          op

          * ----- DC operating point -----
          let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
          let vsrc1op = v(net3)
          let vx1op = v(net8)
          let v9op = v(net9)
          let vbufop = v(vbuf)

          let id1op = abs(@m.xm1.m0[id])
          let gm1op = @m.xm1.m0[gm]
          let gds1op = @m.xm1.m0[gds]
          let vgs1op = v(g_cs)-v(net3)
          let vgd1op = v(g_cs)-v(net8)
          let vgb1op = v(g_cs)
          let vds1op = v(net8)-v(net3)
          let vdsat1op = abs(@m.xm1.m0[vdsat])
          let sat1op = vds1op-vdsat1op

          let id2op = abs(@m.xm2.m0[id])
          let gm2op = @m.xm2.m0[gm]
          let gmb2op = @m.xm2.m0[gmbs]
          let gm2effop = gm2op+gmb2op
          let vds2op = v(d)-v(s)
          let vdsat2op = abs(@m.xm2.m0[vdsat])
          let sat2op = vds2op-vdsat2op

          let id3op = abs(@m.xm3.m0[id])
          let gm3op = @m.xm3.m0[gm]
          let gds3op = @m.xm3.m0[gds]
          let vds3op = v(vdcbias)-v(vbuf)
          let vdsat3op = abs(@m.xm3.m0[vdsat])
          let sat3op = vds3op-vdsat3op

          let id4op = abs(@m.xm4.m0[id])
          let gm4op = @m.xm4.m0[gm]
          let gds4op = @m.xm4.m0[gds]
          let vds4op = v(net9)-v(net8)
          let vdsat4op = abs(@m.xm4.m0[vdsat])
          let sat4op = vds4op-vdsat4op

          let id5op = abs(@m.xm5.m0[id])
          let gm5op = @m.xm5.m0[gm]
          let gds5op = @m.xm5.m0[gds]
          let vds5op = v(s)
          let vdsat5op = abs(@m.xm5.m0[vdsat])
          let sat5op = vds5op-vdsat5op

          let id6op = abs(@m.xm6.m0[id])
          let gm6op = @m.xm6.m0[gm]
          let gds6op = @m.xm6.m0[gds]
          let vds6op = v(vbuf)
          let vdsat6op = abs(@m.xm6.m0[vdsat])
          let sat6op = vds6op-vdsat6op

          let ratio25op = gm2effop/gm5op
          let ltotalop = 2.0e-9

          set op_pdc = $&pdcop
          set op_vsrc1 = $&vsrc1op
          set op_vx1 = $&vx1op
          set op_v9 = $&v9op
          set op_vbuf = $&vbufop
          set op_id1 = $&id1op
          set op_vgs1 = $&vgs1op
          set op_vgd1 = $&vgd1op
          set op_vgb1 = $&vgb1op
          set op_vds1 = $&vds1op
          set op_sat1 = $&sat1op
          set op_id2 = $&id2op
          set op_gm2eff = $&gm2effop
          set op_sat2 = $&sat2op
          set op_id3 = $&id3op
          set op_sat3 = $&sat3op
          set op_id4 = $&id4op
          set op_sat4 = $&sat4op
          set op_id5 = $&id5op
          set op_gm5 = $&gm5op
          set op_gds5 = $&gds5op
          set op_sat5 = $&sat5op
          set op_id6 = $&id6op
          set op_sat6 = $&sat6op
          set op_ratio25 = $&ratio25op
          set op_ltotal = $&ltotalop

          destroy $curplot

          * ----- Target-band S/noise/stability -----
          sp lin 101 2.30G 2.50G 1
          let s11db = db(s_1_1)
          let s21db = db(s_2_1)
          let s12db = db(s_1_2)
          let s22db = db(s_2_2)
          let nfdb = real(NF)

          let delta = s_1_1*s_2_2-s_1_2*s_2_1
          let md = mag(delta)
          let a11 = mag(s_1_1)
          let a12 = mag(s_1_2)
          let a21 = mag(s_2_1)
          let a22 = mag(s_2_2)
          let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
          let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

          let s11w = maximum(s11db)
          let s21m = minimum(s21db)
          let s21x = maximum(s21db)
          let ripple = s21x-s21m
          let tilt = abs(s21db[0]-s21db[100])
          let s22w = maximum(s22db)
          let nfw = maximum(nfdb)
          let mumin = minimum(mu)
          let mupmin = minimum(mup)
          let dmax = maximum(md)

          let passcount = 0
          if s11w <= target_s11
            let passcount = passcount+1
          end
          if s22w <= target_s22
            let passcount = passcount+1
          end
          if s21m >= target_gain
            let passcount = passcount+1
          end
          if nfw <= target_nf
            let passcount = passcount+1
          end
          if ripple <= target_ripple
            let passcount = passcount+1
          end
          if $op_pdc <= target_pdc
            let passcount = passcount+1
          end
          if mumin >= target_mu
            let passcount = passcount+1
          end
          if mupmin >= target_mu
            let passcount = passcount+1
          end
          if dmax < target_delta
            let passcount = passcount+1
          end

          let dcvalid = 1
          if $op_pdc > target_pdc
            let dcvalid = 0
          end
          if $op_sat1 < min_satmargin_xm1
            let dcvalid = 0
          end
          if $op_sat2 < min_satmargin_cg
            let dcvalid = 0
          end
          if $op_sat3 < min_satmargin_core
            let dcvalid = 0
          end
          if $op_sat4 < min_satmargin_core
            let dcvalid = 0
          end
          if $op_sat5 < min_satmargin_sink
            let dcvalid = 0
          end
          if $op_sat6 < min_satmargin_sink
            let dcvalid = 0
          end
          if $op_id5 < 0.0015
            let dcvalid = 0
          end
          if $op_id5 > 0.0060
            let dcvalid = 0
          end
          if $op_id6 < 0.015
            let dcvalid = 0
          end
          if $op_id6 > 0.060
            let dcvalid = 0
          end
          if abs($op_vgs1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vgd1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vgb1) > max_03v3_terminal
            let dcvalid = 0
          end
          if abs($op_vds1) > max_03v3_terminal
            let dcvalid = 0
          end
          if $op_ltotal > ltotal_limit
            let dcvalid = 0
          end
          if $op_v9 <= $op_vx1
            let dcvalid = 0
          end
          if $op_vx1 <= $op_vsrc1
            let dcvalid = 0
          end

          let passall = 1
          if passcount < 9
            let passall = 0
          end
          if dcvalid = 0
            let passall = 0
          end

          let pgain = 0
          let pnf = 0
          let pripple = 0
          let ptilt = 0
          let ps11 = 0
          let ps22 = 0
          let ppdc = 0
          let pmu = 0
          let pmup = 0
          let psat5 = 0
          let pratio = 0

          if s21m < margin_gain
            let pgain = margin_gain-s21m
          end
          if nfw > margin_nf
            let pnf = nfw-margin_nf
          end
          if ripple > margin_ripple
            let pripple = ripple-margin_ripple
          end
          if tilt > margin_tilt
            let ptilt = tilt-margin_tilt
          end
          if s11w > margin_s11
            let ps11 = s11w-margin_s11
          end
          if s22w > margin_s22
            let ps22 = s22w-margin_s22
          end
          if $op_pdc > margin_pdc
            let ppdc = $op_pdc-margin_pdc
          end
          if mumin < margin_mu_band
            let pmu = margin_mu_band-mumin
          end
          if mupmin < margin_mu_band
            let pmup = margin_mu_band-mupmin
          end
          if $op_sat5 < margin_sat5
            let psat5 = margin_sat5-$op_sat5
          end
          if $op_ratio25 < margin_ratio25
            let pratio = margin_ratio25-$op_ratio25
          end

          let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
          let score = score+25*ps11+25*ps22+0.02*ppdc
          let score = score+75*pmu+75*pmup
          let score = score+20*psat5+5*pratio
          let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

          if passall = 0
            let score = score+1e7
          end
          if dcvalid = 0
            let score = score+1e8
          end

          echo F_JOINT C12 $c12v REQ $reqv CEQ $ceqv RD2 $rd2v COUT $coutv SCORE $&score DCVALID
+ $&dcvalid PASSCOUNT $&passcount PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w
+ S21MIN $&s21m S21MAX $&s21x RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin
+ DELTA $&dmax >> lna_v26_gain_nf_priority_summary.txt

          if score < $global_best_score
            set global_best_score = $&score
            set best_c12 = $c12v
          set best_req = $reqv
          set best_ceq = $ceqv
          set best_rd2 = $rd2v
          set best_cout = $coutv
          end

          destroy $curplot

        end
      end
    end
  end
end
echo GLOBAL_AFTER_F SCORE $global_best_score C12 $best_c12 REQ $best_req CEQ $best_ceq RD2 $best_rd2
+ COUT $best_cout >> lna_v26_gain_nf_priority_summary.txt

* =============================================================================
* STAGE G — SOURCE-FOLLOWER GAIN / BIAS / GATE-STOPPER SEARCH: 4 x 3 x 2 x 4 x 4 = 384
* =============================================================================
echo STAGE_G_FOLLOWER_GAIN >> lna_v26_gain_nf_priority_summary.txt
foreach wsf 125u 140u 150u 165u
  foreach w6 50u 60u 70u
    foreach m6 3 4
      foreach vbufv 2.10 2.20 2.30 2.40
        foreach rgv 0.01 0.25 0.50 1.0

    alterparam W_CG = $best_wcg
    alterparam VBIAS_CG = $best_vbcg
    alterparam RD1 = $best_rd1
    alterparam L_BIAS_CG = $best_l5
    alterparam W_BIAS_CG = $best_w5
    alterparam VBIAS_ICG = $best_vbicg
    alterparam C12_VAL = $best_c12
    alterparam RS_EQ = $best_req
    alterparam CSEQ_VAL = $best_ceq
    alterparam RD2 = $best_rd2
    alterparam COUT_VAL = $best_cout
    alterparam RG_SF_VAL = $best_rg
    alterparam C_STAB_VAL = $best_cstab
    alterparam R_STAB_VAL = $best_rstab
    alterparam W_SF = $best_wsf
    alterparam L_BIAS_SF = $best_l6
    alterparam W_BIAS_SF = $best_w6
    alterparam M_BIAS_SF = $best_m6
    alterparam VBIAS_BUF = $best_vbuf

        alterparam W_SF = $wsf
        alterparam W_BIAS_SF = $w6
        alterparam M_BIAS_SF = $m6
        alterparam VBIAS_BUF = $vbufv
        alterparam RG_SF_VAL = $rgv

    reset
    op

    * ----- DC operating point -----
    let pdcop = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
    let vsrc1op = v(net3)
    let vx1op = v(net8)
    let v9op = v(net9)
    let vbufop = v(vbuf)

    let id1op = abs(@m.xm1.m0[id])
    let gm1op = @m.xm1.m0[gm]
    let gds1op = @m.xm1.m0[gds]
    let vgs1op = v(g_cs)-v(net3)
    let vgd1op = v(g_cs)-v(net8)
    let vgb1op = v(g_cs)
    let vds1op = v(net8)-v(net3)
    let vdsat1op = abs(@m.xm1.m0[vdsat])
    let sat1op = vds1op-vdsat1op

    let id2op = abs(@m.xm2.m0[id])
    let gm2op = @m.xm2.m0[gm]
    let gmb2op = @m.xm2.m0[gmbs]
    let gm2effop = gm2op+gmb2op
    let vds2op = v(d)-v(s)
    let vdsat2op = abs(@m.xm2.m0[vdsat])
    let sat2op = vds2op-vdsat2op

    let id3op = abs(@m.xm3.m0[id])
    let gm3op = @m.xm3.m0[gm]
    let gds3op = @m.xm3.m0[gds]
    let vds3op = v(vdcbias)-v(vbuf)
    let vdsat3op = abs(@m.xm3.m0[vdsat])
    let sat3op = vds3op-vdsat3op

    let id4op = abs(@m.xm4.m0[id])
    let gm4op = @m.xm4.m0[gm]
    let gds4op = @m.xm4.m0[gds]
    let vds4op = v(net9)-v(net8)
    let vdsat4op = abs(@m.xm4.m0[vdsat])
    let sat4op = vds4op-vdsat4op

    let id5op = abs(@m.xm5.m0[id])
    let gm5op = @m.xm5.m0[gm]
    let gds5op = @m.xm5.m0[gds]
    let vds5op = v(s)
    let vdsat5op = abs(@m.xm5.m0[vdsat])
    let sat5op = vds5op-vdsat5op

    let id6op = abs(@m.xm6.m0[id])
    let gm6op = @m.xm6.m0[gm]
    let gds6op = @m.xm6.m0[gds]
    let vds6op = v(vbuf)
    let vdsat6op = abs(@m.xm6.m0[vdsat])
    let sat6op = vds6op-vdsat6op

    let ratio25op = gm2effop/gm5op
    let ltotalop = 2.0e-9

    set op_pdc = $&pdcop
    set op_vsrc1 = $&vsrc1op
    set op_vx1 = $&vx1op
    set op_v9 = $&v9op
    set op_vbuf = $&vbufop
    set op_id1 = $&id1op
    set op_vgs1 = $&vgs1op
    set op_vgd1 = $&vgd1op
    set op_vgb1 = $&vgb1op
    set op_vds1 = $&vds1op
    set op_sat1 = $&sat1op
    set op_id2 = $&id2op
    set op_gm2eff = $&gm2effop
    set op_sat2 = $&sat2op
    set op_id3 = $&id3op
    set op_sat3 = $&sat3op
    set op_id4 = $&id4op
    set op_sat4 = $&sat4op
    set op_id5 = $&id5op
    set op_gm5 = $&gm5op
    set op_gds5 = $&gds5op
    set op_sat5 = $&sat5op
    set op_id6 = $&id6op
    set op_sat6 = $&sat6op
    set op_ratio25 = $&ratio25op
    set op_ltotal = $&ltotalop

    destroy $curplot

    * ----- Target-band S/noise/stability -----
    sp lin 101 2.30G 2.50G 1
    let s11db = db(s_1_1)
    let s21db = db(s_2_1)
    let s12db = db(s_1_2)
    let s22db = db(s_2_2)
    let nfdb = real(NF)

    let delta = s_1_1*s_2_2-s_1_2*s_2_1
    let md = mag(delta)
    let a11 = mag(s_1_1)
    let a12 = mag(s_1_2)
    let a21 = mag(s_2_1)
    let a22 = mag(s_2_2)
    let mu = (1-a11*a11)/(mag(s_2_2-delta*conj(s_1_1))+mag(s_1_2*s_2_1))
    let mup = (1-a22*a22)/(mag(s_1_1-delta*conj(s_2_2))+mag(s_1_2*s_2_1))

    let s11w = maximum(s11db)
    let s21m = minimum(s21db)
    let s21x = maximum(s21db)
    let ripple = s21x-s21m
    let tilt = abs(s21db[0]-s21db[100])
    let s22w = maximum(s22db)
    let nfw = maximum(nfdb)
    let mumin = minimum(mu)
    let mupmin = minimum(mup)
    let dmax = maximum(md)

    let passcount = 0
    if s11w <= target_s11
      let passcount = passcount+1
    end
    if s22w <= target_s22
      let passcount = passcount+1
    end
    if s21m >= target_gain
      let passcount = passcount+1
    end
    if nfw <= target_nf
      let passcount = passcount+1
    end
    if ripple <= target_ripple
      let passcount = passcount+1
    end
    if $op_pdc <= target_pdc
      let passcount = passcount+1
    end
    if mumin >= target_mu
      let passcount = passcount+1
    end
    if mupmin >= target_mu
      let passcount = passcount+1
    end
    if dmax < target_delta
      let passcount = passcount+1
    end

    let dcvalid = 1
    if $op_pdc > target_pdc
      let dcvalid = 0
    end
    if $op_sat1 < min_satmargin_xm1
      let dcvalid = 0
    end
    if $op_sat2 < min_satmargin_cg
      let dcvalid = 0
    end
    if $op_sat3 < min_satmargin_core
      let dcvalid = 0
    end
    if $op_sat4 < min_satmargin_core
      let dcvalid = 0
    end
    if $op_sat5 < min_satmargin_sink
      let dcvalid = 0
    end
    if $op_sat6 < min_satmargin_sink
      let dcvalid = 0
    end
    if $op_id5 < 0.0015
      let dcvalid = 0
    end
    if $op_id5 > 0.0060
      let dcvalid = 0
    end
    if $op_id6 < 0.015
      let dcvalid = 0
    end
    if $op_id6 > 0.060
      let dcvalid = 0
    end
    if abs($op_vgs1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vgd1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vgb1) > max_03v3_terminal
      let dcvalid = 0
    end
    if abs($op_vds1) > max_03v3_terminal
      let dcvalid = 0
    end
    if $op_ltotal > ltotal_limit
      let dcvalid = 0
    end
    if $op_v9 <= $op_vx1
      let dcvalid = 0
    end
    if $op_vx1 <= $op_vsrc1
      let dcvalid = 0
    end

    let passall = 1
    if passcount < 9
      let passall = 0
    end
    if dcvalid = 0
      let passall = 0
    end

    let pgain = 0
    let pnf = 0
    let pripple = 0
    let ptilt = 0
    let ps11 = 0
    let ps22 = 0
    let ppdc = 0
    let pmu = 0
    let pmup = 0
    let psat5 = 0
    let pratio = 0

    if s21m < margin_gain
      let pgain = margin_gain-s21m
    end
    if nfw > margin_nf
      let pnf = nfw-margin_nf
    end
    if ripple > margin_ripple
      let pripple = ripple-margin_ripple
    end
    if tilt > margin_tilt
      let ptilt = tilt-margin_tilt
    end
    if s11w > margin_s11
      let ps11 = s11w-margin_s11
    end
    if s22w > margin_s22
      let ps22 = s22w-margin_s22
    end
    if $op_pdc > margin_pdc
      let ppdc = $op_pdc-margin_pdc
    end
    if mumin < margin_mu_band
      let pmu = margin_mu_band-mumin
    end
    if mupmin < margin_mu_band
      let pmup = margin_mu_band-mupmin
    end
    if $op_sat5 < margin_sat5
      let psat5 = margin_sat5-$op_sat5
    end
    if $op_ratio25 < margin_ratio25
      let pratio = margin_ratio25-$op_ratio25
    end

    let score = 5000*pgain+8000*pnf+300*pripple+50*ptilt
    let score = score+25*ps11+25*ps22+0.02*ppdc
    let score = score+75*pmu+75*pmup
    let score = score+20*psat5+5*pratio
    let score = score+20*nfw+10*ripple+2*tilt-0.75*s21m+0.0005*$op_pdc

    if passall = 0
      let score = score+1e7
    end
    if dcvalid = 0
      let score = score+1e8
    end

    echo G_FOLLOWER WSF $wsf W6 $w6 M6 $m6 VBUF $vbufv RG $rgv SCORE $&score DCVALID $&dcvalid
+ PASSCOUNT $&passcount PASSALL $&passall PDC $op_pdc SAT5 $op_sat5 RATIO25 $op_ratio25 S11W $&s11w S21MIN
+ $&s21m S21MAX $&s21x RIPPLE $&ripple TILT $&tilt S22W $&s22w NFW $&nfw MU $&mumin MUP $&mupmin DELTA
+ $&dmax >> lna_v26_gain_nf_priority_summary.txt

    if score < $global_best_score
      set global_best_score = $&score
      set best_wsf = $wsf
      set best_w6 = $w6
      set best_m6 = $m6
      set best_vbuf = $vbufv
      set best_rg = $rgv
    end

    destroy $curplot

        end
      end
    end
  end
end
echo GLOBAL_AFTER_G SCORE $global_best_score WSF $best_wsf W6 $best_w6 M6 $best_m6 VBUF $best_vbuf
+ RG $best_rg >> lna_v26_gain_nf_priority_summary.txt


* =============================================================================
* FINAL VERIFICATION
* =============================================================================
alterparam W_CG = $best_wcg
alterparam VBIAS_CG = $best_vbcg
alterparam RD1 = $best_rd1
alterparam L_BIAS_CG = $best_l5
alterparam W_BIAS_CG = $best_w5
alterparam VBIAS_ICG = $best_vbicg
alterparam C12_VAL = $best_c12
alterparam RS_EQ = $best_req
alterparam CSEQ_VAL = $best_ceq
alterparam RD2 = $best_rd2
alterparam COUT_VAL = $best_cout
alterparam RG_SF_VAL = $best_rg
alterparam C_STAB_VAL = $best_cstab
alterparam R_STAB_VAL = $best_rstab
alterparam W_SF = $best_wsf
alterparam L_BIAS_SF = $best_l6
alterparam W_BIAS_SF = $best_w6
alterparam M_BIAS_SF = $best_m6
alterparam VBIAS_BUF = $best_vbuf

reset
op
let final_pdc = 1e3*(abs(i(VDD))*v(vdcbias)+abs(i(VDDIO))*v(vddio))
let final_vsrc1 = v(net3)
let final_vx1 = v(net8)
let final_v9 = v(net9)
let final_vbuf = v(vbuf)
let final_id1 = abs(@m.xm1.m0[id])
let final_vgs1 = v(g_cs)-v(net3)
let final_vgd1 = v(g_cs)-v(net8)
let final_vds1 = v(net8)-v(net3)
let final_sat1 = final_vds1-abs(@m.xm1.m0[vdsat])
let final_id2 = abs(@m.xm2.m0[id])
let final_sat2 = v(d)-v(s)-abs(@m.xm2.m0[vdsat])
let final_id3 = abs(@m.xm3.m0[id])
let final_sat3 = v(vdcbias)-v(vbuf)-abs(@m.xm3.m0[vdsat])
let final_id4 = abs(@m.xm4.m0[id])
let final_sat4 = v(net9)-v(net8)-abs(@m.xm4.m0[vdsat])
let final_id5 = abs(@m.xm5.m0[id])
let final_gm5 = @m.xm5.m0[gm]
let final_gds5 = @m.xm5.m0[gds]
let final_sat5 = v(s)-abs(@m.xm5.m0[vdsat])
let final_gm2eff = @m.xm2.m0[gm]+@m.xm2.m0[gmbs]
let final_ratio25 = final_gm2eff/final_gm5
let final_id6 = abs(@m.xm6.m0[id])
let final_sat6 = v(vbuf)-abs(@m.xm6.m0[vdsat])

set f_pdc = $&final_pdc
set f_vsrc1 = $&final_vsrc1
set f_vx1 = $&final_vx1
set f_v9 = $&final_v9
set f_vbuf = $&final_vbuf
set f_id1 = $&final_id1
set f_vgs1 = $&final_vgs1
set f_vgd1 = $&final_vgd1
set f_vds1 = $&final_vds1
set f_sat1 = $&final_sat1
set f_id2 = $&final_id2
set f_sat2 = $&final_sat2
set f_id3 = $&final_id3
set f_sat3 = $&final_sat3
set f_id4 = $&final_id4
set f_sat4 = $&final_sat4
set f_id5 = $&final_id5
set f_gds5 = $&final_gds5
set f_sat5 = $&final_sat5
set f_ratio25 = $&final_ratio25
set f_id6 = $&final_id6
set f_sat6 = $&final_sat6
destroy $curplot

sp lin 201 2.30G 2.50G 1
let fs11db = db(s_1_1)
let fs21db = db(s_2_1)
let fs12db = db(s_1_2)
let fs22db = db(s_2_2)
let fnfdb = real(NF)
let fdelta = s_1_1*s_2_2-s_1_2*s_2_1
let fmd = mag(fdelta)
let fa11 = mag(s_1_1)
let fa12 = mag(s_1_2)
let fa21 = mag(s_2_1)
let fa22 = mag(s_2_2)
let fmu = (1-fa11*fa11)/(mag(s_2_2-fdelta*conj(s_1_1))+mag(s_1_2*s_2_1))
let fmup = (1-fa22*fa22)/(mag(s_1_1-fdelta*conj(s_2_2))+mag(s_1_2*s_2_1))
let fzin = 50*(1+s_1_1)/(1-s_1_1)
let fzout = 50*(1+s_2_2)/(1-s_2_2)

let fs11w = maximum(fs11db)
let fs21m = minimum(fs21db)
let fs21x = maximum(fs21db)
let fripple = fs21x-fs21m
let ftilt = abs(fs21db[0]-fs21db[200])
let fs22w = maximum(fs22db)
let fnfw = maximum(fnfdb)
let fmumin = minimum(fmu)
let fmupmin = minimum(fmup)
let fdmax = maximum(fmd)

let fpasscount = 0
if fs11w <= target_s11
  let fpasscount = fpasscount+1
end
if fs22w <= target_s22
  let fpasscount = fpasscount+1
end
if fs21m >= target_gain
  let fpasscount = fpasscount+1
end
if fnfw <= target_nf
  let fpasscount = fpasscount+1
end
if fripple <= target_ripple
  let fpasscount = fpasscount+1
end
if $f_pdc <= target_pdc
  let fpasscount = fpasscount+1
end
if fmumin >= target_mu
  let fpasscount = fpasscount+1
end
if fmupmin >= target_mu
  let fpasscount = fpasscount+1
end
if fdmax < target_delta
  let fpasscount = fpasscount+1
end

let formal_pass = 1
if fpasscount < 9
  let formal_pass = 0
end

let dc_pass = 1
if $f_sat1 < min_satmargin_xm1
  let dc_pass = 0
end
if $f_sat2 < min_satmargin_cg
  let dc_pass = 0
end
if $f_sat3 < min_satmargin_core
  let dc_pass = 0
end
if $f_sat4 < min_satmargin_core
  let dc_pass = 0
end
if $f_sat5 < min_satmargin_sink
  let dc_pass = 0
end
if $f_sat6 < min_satmargin_sink
  let dc_pass = 0
end
if abs($f_vgs1) > max_03v3_terminal
  let dc_pass = 0
end
if abs($f_vgd1) > max_03v3_terminal
  let dc_pass = 0
end
if abs($f_vds1) > max_03v3_terminal
  let dc_pass = 0
end

set fb_s11w = $&fs11w
set fb_s21m = $&fs21m
set fb_s21x = $&fs21x
set fb_ripple = $&fripple
set fb_tilt = $&ftilt
set fb_s22w = $&fs22w
set fb_nfw = $&fnfw
set fb_mumin = $&fmumin
set fb_mupmin = $&fmupmin
set fb_dmax = $&fdmax
set fb_passcount = $&fpasscount
set fb_formal = $&formal_pass
set fb_dc = $&dc_pass

echo ============================================================ >>
+ lna_v26_gain_nf_priority_detailed.txt
echo FINAL_TARGET_BAND_2P30_TO_2P50_GHZ >> lna_v26_gain_nf_priority_detailed.txt
wrdata lna_v26_gain_nf_priority_detailed.txt frequency s_1_1 s_2_1 s_1_2 s_2_2 fs11db fs21db fs12db
+ fs22db fnfdb fmu fmup fmd fzin fzout
destroy $curplot

sp dec 100 10Meg 30Gig
let fwdelta = s_1_1*s_2_2-s_1_2*s_2_1
let fwmd = mag(fwdelta)
let fwa11 = mag(s_1_1)
let fwa12 = mag(s_1_2)
let fwa21 = mag(s_2_1)
let fwa22 = mag(s_2_2)
let fwmu = (1-fwa11*fwa11)/(mag(s_2_2-fwdelta*conj(s_1_1))+mag(s_1_2*s_2_1))
let fwmup = (1-fwa22*fwa22)/(mag(s_1_1-fwdelta*conj(s_2_2))+mag(s_1_2*s_2_1))
let fwmumin = minimum(fwmu)
let fwmupmin = minimum(fwmup)

let margin_pass = 1
if $fb_s11w > margin_s11
  let margin_pass = 0
end
if $fb_s22w > margin_s22
  let margin_pass = 0
end
if $fb_s21m < margin_gain
  let margin_pass = 0
end
if $fb_nfw > margin_nf
  let margin_pass = 0
end
if $fb_ripple > margin_ripple
  let margin_pass = 0
end
if $fb_tilt > margin_tilt
  let margin_pass = 0
end
if $f_pdc > margin_pdc
  let margin_pass = 0
end
if $f_sat5 < margin_sat5
  let margin_pass = 0
end
if $f_ratio25 < margin_ratio25
  let margin_pass = 0
end
if fwmumin < margin_mu_wide
  let margin_pass = 0
end
if fwmupmin < margin_mu_wide
  let margin_pass = 0
end

echo ============================================================ >>
+ lna_v26_gain_nf_priority_summary.txt
echo FINAL_SELECTED >> lna_v26_gain_nf_priority_summary.txt
echo PARAMS W_CG $best_wcg VBIAS_CG $best_vbcg RD1 $best_rd1 L5 $best_l5 W5 $best_w5 VBICG
+ $best_vbicg C12 $best_c12 REQ $best_req CEQ $best_ceq RD2 $best_rd2 COUT $best_cout WSF $best_wsf L6 $best_l6
+ W6 $best_w6 M6 $best_m6 VBUF_BIAS $best_vbuf RG $best_rg CSTAB $best_cstab RSTAB $best_rstab >>
+ lna_v26_gain_nf_priority_summary.txt
echo FIXED LIN 1.80n LOUT 0.20n WCS 40u LCS 0.28u VBCS 0.95 WCAS 70u VBCAS 3.30 >>
+ lna_v26_gain_nf_priority_summary.txt
echo DC PDC_MW $f_pdc VSRC1 $f_vsrc1 VX1 $f_vx1 V9 $f_v9 VBUF $f_vbuf ID1 $f_id1 SAT1 $f_sat1 ID2
+ $f_id2 SAT2 $f_sat2 ID3 $f_id3 SAT3 $f_sat3 ID4 $f_id4 SAT4 $f_sat4 ID5 $f_id5 GDS5 $f_gds5 SAT5 $f_sat5
+ RATIO25 $f_ratio25 ID6 $f_id6 SAT6 $f_sat6 >> lna_v26_gain_nf_priority_summary.txt
echo BAND S11W $fb_s11w S21MIN $fb_s21m S21MAX $fb_s21x RIPPLE $fb_ripple TILT $fb_tilt S22W
+ $fb_s22w NFW $fb_nfw MU $fb_mumin MUP $fb_mupmin DELTA $fb_dmax >> lna_v26_gain_nf_priority_summary.txt
echo WIDEBAND_10MEG_30G MU_MIN $&fwmumin MUP_MIN $&fwmupmin >> lna_v26_gain_nf_priority_summary.txt
echo RESULT PASSCOUNT $fb_passcount FORMAL_PASS $fb_formal DC_PASS $fb_dc MARGIN_PASS $&margin_pass
+ >> lna_v26_gain_nf_priority_summary.txt
echo ============================================================ >>
+ lna_v26_gain_nf_priority_summary.txt

echo ============================================================ >>
+ lna_v26_gain_nf_priority_detailed.txt
echo FINAL_WIDEBAND_10MEG_TO_30GHZ >> lna_v26_gain_nf_priority_detailed.txt
wrdata lna_v26_gain_nf_priority_detailed.txt frequency s_1_1 s_2_1 s_1_2 s_2_2 fwmu fwmup fwmd
destroy $curplot

quit
.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
